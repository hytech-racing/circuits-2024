# Repository hytech-racing/circuits-2024 (continued)

## EAGLE design EAGLE Board Designs/Sensor Acquisition Board/Sensor Acquisition Board Rev5.brd (continued)

Parts:
3V3, 5V, 12V: TEST_POINT; 5015
A1: VOLTAGE_REGULATOR_MODULE_OKI-78SR_12V; OKI-78SR
A2: VOLTAGE_REGULATOR_MODULE_OKI-78SR_5V; OKI-78SR
C1, C2, C4: CAPACITOR_0805_50V_10UF; 0805-CAP
C3, C5, C6: CAPACITOR_0603_25V_10UF; 0603-CAP
C7: CAPACITOR_ELECTROLYTIC_EEH_AZS_470UF; EEH-AZS
D1: LED_0603_RED; 0603-LED
D2: LED_0603_YELLOW; 0603-LED
D3: LED_0603_GREEN; 0603-LED
D4: TVS_DO-219AB_14V; SMF
D6: TVS_DO-214AA_30V; 1.5SMBJ
GND: TEST_POINT; 5015
R1: RESISTOR_0603_1K; 0603-RES
R2: RESISTOR_0603_240; 0603-RES
R3: RESISTOR_0603_120; 0603-RES
U1: VOLTAGE_REGULATOR_SOT-223_3.3V; SOT-223
XF1: FUSE_HOLDER_MINIBLADESMD; 3588

Connections:
24VIN: D6.2 (C), XF1.1, XF1.2 (1); also elsewhere on the board
+3V3: 3V3.1, C6.1, R3.1, U1.2 (OUT), U1.4 (OUT); also elsewhere on the board
+5V: 5V.1, A2.3 (OUT), C3.1, C5.1, R2.1, U1.3 (IN); also elsewhere on the board
+12V: 12V.1, A1.3 (OUT), C4.1, D4.P$2 (C), R1.1; also elsewhere on the board
+24V: A1.1 (IN), A2.1 (IN), C1.1, C2.1, C7.PLUS, XF1.3 (2), XF1.4 (2); also elsewhere on the board
GND: A1.2 (GND), A2.2 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.MINUS, D1.1 (C), D2.1 (C), D3.1 (C), D4.P$1 (A), D6.1 (A), GND.1, U1.1 (GND); also elsewhere on the board
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2

Notes on the sheet:
Voltage regulators
24V -> 12V Aero sensor Ride height Thermistor IMU
Fuse GLV 24V
Power indication LEDs
Overvoltage protection IMU
Cannot add 5V TVS Always clamping if same voltage as supply
Bulk cap Might not need this large capacity
Cecilia Yang
Possible RPPs: Shottky with higher current MOSFET

Parts:
C8, C9, C10, C11, C12, C13, C14, C15: CAPACITOR_0603_10V_1UF; 0603-CAP
R4, R5, R6, R7, R8, R9, R10, R11: RESISTOR_0603_8.35K; 0603-RES

Connections:
+3V3: R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1; also elsewhere on the board
GND: C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2; also elsewhere on the board
THERM1: C8.1, R4.2; also elsewhere on the board
THERM2: C9.1, R5.2; also elsewhere on the board
THERM3: C10.1, R6.2; also elsewhere on the board
THERM4: C11.1, R7.2; also elsewhere on the board
THERM5: C12.1, R8.2; also elsewhere on the board
THERM6: C13.1, R9.2; also elsewhere on the board
THERM7: C14.1, R10.2; also elsewhere on the board
THERM8: C15.1, R11.2; also elsewhere on the board

Notes on the sheet:
Thermistors
Filter analog input
Resistor select: Geometric mean Largest change in voltage range given target temperature range
Future consideration: adjustable lin reg more current output
Cecilia Yang
Got rid of max's Switched to passives
1uF 0603 caps: 3dB fc @ 35Hz fc = (R1+R2)/(2*pi*R1*R2*C) R1: resistor in series R2: thermistor nominal

Parts:
C48, C49, C50, C51, C52: CAPACITOR_0603_35V_0.1UF; 0603-CAP
C53: CAPACITOR_0603_35V_1UF; 0603-CAP
C54, C55: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C56, C57: CAPACITOR_0603_10V_1UF; 0603-CAP
C58, C59: CAPACITOR_0603_10V_15PF; 0603-CAP
D7: TVS_BIDIRECTIONAL_DUAL; SC-70-3
R12, R13: RESISTOR_0603_2K; 0603-RES
R14, R16: RESISTOR_0603_1.33K; 0603-RES
R15, R17: RESISTOR_0603_1.13K; 0603-RES
R18, R19: RESISTOR_0603_120; 0603-RES
RL_IM: TEST_POINT; 5015
RL_IP: TEST_POINT; 5015
RR_IM: TEST_POINT; 5015
RR_IP: TEST_POINT; 5015
T1, T2: 78613/3C_78613/3C; 78613/3C
U10: MAX3227; SSOP-16
U11, U12: LTC6820; MSOP-16

Connections:
!ADC1_CS: U11.5 (!CS); also elsewhere on the board
!ADC2_CS: U12.5 (!CS); also elsewhere on the board
+3V3: C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, R12.2, R13.2, U10.12 (FORCEON), U10.15 (VCC), U10.16 (!FORCEOFF), U11.1 (EN), U11.6 (VLOGIC), U11.9 (VDD), U11.12 (MSTR), U12.1 (EN), U12.6 (VLOGIC), U12.9 (VDD), U12.12 (MSTR); also elsewhere on the board
GND: C50.1, C51.1, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, D7.3 (A), R15.1, R17.1, U10.14 (GND), U11.7 (POL), U11.8 (PHA), U11.13 (SLOW), U11.14 (GND), U12.7 (POL), U12.8 (PHA), U12.13 (SLOW), U12.14 (GND); also elsewhere on the board
unnamed: C50.2, U10.3 (V+)
unnamed: C48.1, U10.2 (C1+)
unnamed: C51.2, U10.7 (V-)
unnamed: R16.2, U12.16 (IBIAS)
unnamed: R16.1, R17.2, U12.15 (ICMP)
unnamed: R14.2, U11.16 (IBIAS)
unnamed: R14.1, R15.2, U11.15 (ICMP)
unnamed: C58.1, T1.2 (PRI_CENTER_TAP)
unnamed: C59.1, T2.2 (PRI_CENTER_TAP)
unnamed: C48.2, U10.4 (C1-)
unnamed: C49.1, U10.5 (C2+)
unnamed: C49.2, U10.6 (C2-)
RL_EXT_N: T1.4 (SEC_1); also elsewhere on the board
RL_EXT_P: T1.6 (SEC_2); also elsewhere on the board
RL_N: R18.1, RL_IM.1, T1.3 (PRI_2), U11.10 (IM)
RL_P: R18.2, RL_IP.1, T1.1 (PRI_1), U11.11 (IP)
RR_EXT_N: T2.4 (SEC_1); also elsewhere on the board
RR_EXT_P: T2.6 (SEC_2); also elsewhere on the board
RR_N: R19.1, RR_IM.1, T2.3 (PRI_2), U12.10 (IM)
RR_P: R19.2, RR_IP.1, T2.1 (PRI_1), U12.11 (IP)
RXD_232: D7.2 (C2), U10.8 (R1IN); also elsewhere on the board
RX_232: U10.9 (R1OUT); also elsewhere on the board
TEENSY_CLK: U11.4 (CLK), U12.4 (CLK); also elsewhere on the board
TEENSY_SDI: R12.1, R13.1, U11.3 (SDO), U12.3 (SDO); also elsewhere on the board
TEENSY_SDO: U11.2 (SDI), U12.2 (SDI); also elsewhere on the board
TXD_232: D7.1 (C1), U10.13 (T1OUT); also elsewhere on the board
TX_232: U10.11 (T1IN); also elsewhere on the board

Notes on the sheet:
isoSPI Rear corner board ADCs
DNP possible Teensy seems to have internal pull-ups
Data output needs pull up Teensy master -> SDO on LTC
IMU RS232 transceiver/level shifter
ESD protection
Cecilia Yang
differential I2C

Parts:
A3: TEENSY_4.0SM; TEENSY_SHORT_SSM
C60: CAPACITOR_0603_10V_4.7NF; 0603-CAP
C61: CAPACITOR_0603_10V_4.7UF; 0603-CAP
C62: CAPACITOR_0603_35V_0.1UF; 0603-CAP
C63, C65, C66, C67: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C64: CAPACITOR_0603_35V_1UF; 0603-CAP
C68, C69: CAPACITOR_0603_10V_1UF; 0603-CAP
CLK: TEST_POINT; 5015
D8, D10: TVS_BIDIRECTIONAL_DUALRS422; SOT-23
D9, D11, D12: TVS_BIDIRECTIONAL_DUAL; SC-70-3
JP4, JP5, JP6: JUMPER_0603_; 0603-RES
MISO: TEST_POINT; 5015
MOSI: TEST_POINT; 5015
R20: RESISTOR_0603_120; 0603-RES
R21, R22: RESISTOR_0603_60.4; 0603-RES
U13: TCAN1051HQV-Q1; SOIC-08(NARROW,0.15")
U14: MAX3075; SOIC-08(NARROW,0.15")
U15: MCP3208; SOIC-16

Connections:
3.3V: A3.3.3V
!ADC1_CS: A3.D2; also elsewhere on the board
!ADC2_CS: A3.D3; also elsewhere on the board
!ADC3_CS: A3.D10 ((CS)D10), U15.10 (!CS!/SHDN)
+3V3: C62.1, C64.1, C65.1, C66.1, C68.1, U13.5 (VIO), U14.8 (VCC), U15.15 (VREF), U15.16 (VDD); also elsewhere on the board
+5V: A3.VIN, C61.1, C63.1, C67.1, C69.1, U13.3 (VDD); also elsewhere on the board
CAN_N: D9.2 (C2), D11.2 (C2), D12.2 (C2), JP4.1, U13.6 (CANL); also elsewhere on the board
CAN_P: D9.1 (C1), D11.1 (C1), D12.1 (C1), JP6.2, U13.7 (CANH); also elsewhere on the board
EN_485: A3.D18 (A4), U14.2 (!RE), U14.3 (DE)
GND: A3.AGND/GND (GND), A3.GND, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, D8.3 (A), D9.3 (A), D10.3 (A), D11.3 (A), D12.3 (A), U13.2 (GND), U13.8 (S), U14.5 (GND), U15.9 (GND), U15.14 (AGND); also elsewhere on the board
GPS_PPS: A3.D4; also elsewhere on the board
unnamed: JP5.1, R20.2
unnamed: JP4.2, R21.1
unnamed: C60.1, R21.2, R22.1
unnamed: JP6.1, R22.2
PI_SHUTDOWN: A3.D14 (A0); also elsewhere on the board
RESTORE: A3.D9; also elsewhere on the board
RHEIGHT_N: D8.2 (C2), D10.2 (C2), JP5.2, U14.7 (B); also elsewhere on the board
RHEIGHT_P: D8.1 (C1), D10.1 (C1), R20.1, U14.6 (A); also elsewhere on the board
RX_232: A3.D7; also elsewhere on the board
RX_485: A3.D16 (A2), U14.1 (RO)
SYNC_IN: A3.D6; also elsewhere on the board
SYNC_OUT: A3.D5; also elsewhere on the board
TEENSY_CAN_RX1: A3.D0 ((CRX1)D0), U13.4 (RXD)
TEENSY_CAN_TX1: A3.D1 ((CTX1)D1), U13.1 (TXD)
TEENSY_CLK: A3.D13 ((CLK)D13), CLK.1, U15.13 (CLK); also elsewhere on the board
TEENSY_SDI: A3.D12 ((SDI)D12), MISO.1, U15.12 (SDO); also elsewhere on the board
TEENSY_SDO: A3.D11 ((SDO)D11), MOSI.1, U15.11 (SDI); also elsewhere on the board
THERM1: U15.1 (CH0); also elsewhere on the board
THERM2: U15.2 (CH1); also elsewhere on the board
THERM3: U15.3 (CH2); also elsewhere on the board
THERM4: U15.4 (CH3); also elsewhere on the board
THERM5: U15.5 (CH4); also elsewhere on the board
THERM6: U15.6 (CH5); also elsewhere on the board
THERM7: U15.7 (CH6); also elsewhere on the board
THERM8: U15.8 (CH7); also elsewhere on the board
TX_232: A3.D8; also elsewhere on the board
TX_485: A3.D17 (A3), U14.4 (DI)

Notes on the sheet:
CAN transceiver and termination Bidirectional TVS/ESD protection
RS485 transceiver Bidirectional TVS/ESD protection Ride height sensors
s tie to gnd
Jumper x 2 Only unjump one side would low pass filter CAN
DNP termination resistors Stub line length in theory is short enough
ADC Digitize analog signals Thermistors
Cecilia Yang

Board: 4 copper layers, 199.5 x 94.6 mm, 130 parts (10 on the bottom side), 69 nets.

Other parts of the board:
U$1: LOGO_HYTECH_MEDIUM
U$2: LOGO_GT_MEDIUM
U$3, U$4, U$5, U$6: MOUNTING_M3
U$7, U$8: LOGO_HYTECH_SQUARE_LARGE

File EAGLE Board Designs/Sensor Acquisition Board/Order Files/SAB Rev5 BOM.csv:

"Board Quantity","Ordering Quantity","Value","Reference","ATTRITION","CAPACITANCE","COLOR","DKPN","FUSE_TYPE","MANUFACTURER","MOPN","MPN","POWER","RESISTANCE","TEENSY","TOLERANCE","VOLTAGE","VOLTAGE_CONTINUOUS","VOLTAGE_MAX",
"2","4","78613/3C_78613/3C","T1, T2","100","","","811-3726-ND","","Murata Power Solutions","580-786133C","78613/3C","","","","","","","",
"6","16","CAPACITOR_0603_10V_0.1UF","C54, C55, C63, C65, C66, C67","167","0.1µF","","720-1688-1-ND","","Vishay Vitramon","77-VJ0603Y104JXQPBC","VJ0603Y104JXQPW1BC","","","","5%","10V","","",
"2","12","CAPACITOR_0603_10V_15PF","C58, C59","500","15pF","","720-VJ0603A150FXQPW1BCCT-ND","","Vishay Vitramon","77-VJ0603A150FXQPBC","VJ0603A150FXQPW1BC","","","","1%","10V","","",
"12","22","CAPACITOR_0603_10V_1UF","C8, C9, C10, C11, C12, C13, C14, C15, C56, C57, C68, C69","83","1µF","","311-1796-1-ND","","Yageo","603-CC603KRX7R6BB105","CC0603KRX7R6BB105","","","","10%","10V","","",
"1","11","CAPACITOR_0603_10V_4.7NF","C60","1000","4.7nF","","732-7931-1-ND","","Würth Elektronik","710-885012206012","885012206012","","","","10%","10V","","",
"1","11","CAPACITOR_0603_10V_4.7UF","C61","1000","4.7µF","","1276-1044-1-ND","","Samsung Electro-Mechanics","187-CL10A475KP8NNNC","CL10A475KP8NNNC","","","","10%","10V","","",
"3","13","CAPACITOR_0603_25V_10UF","C3, C5, C6","333","10µF","","490-7202-1-ND","","Murata Electronics","81-GRM188R61E106MA3D","GRM188R61E106MA73D","","","","20%","25V","","",
"6","16","CAPACITOR_0603_35V_0.1UF","C48, C49, C50, C51, C52, C62","167","0.1µF","","587-3354-1-ND","","Taiyo Yuden","963-GMK107B7104KAHT","GMK107B7104KAHT","","","","10%","35V","","",
"2","12","CAPACITOR_0603_35V_1UF","C53, C64","500","1µF","","445-173625-1-ND","","TDK Corporation","810-C1608X7R1V105KAE","C1608X7R1V105K080AE","","","","10%","35V","","",
"3","13","CAPACITOR_0805_50V_10UF","C1, C2, C4","333","10uF","","490-18663-2-ND","","Murata","81-GRM21BR61H106KE3L"," GRM21BR61H106KE43L","","","","10%","50V","","",
"1","3","CAPACITOR_ELECTROLYTIC_EEH_AZS_470UF","C7","200","470uF","","10-EEH-AZS1V471BCT-ND","","Panasonic Electronic Components","667-EEH-AZS1V471B","EEH-AZS1V471B","","","","20&","35V","","",
"1","3","CONNECTOR-10_MF_T_V_","J10","200","","","WM1799-ND","","MOLEX","538-43045-1014","430451014","","","","","","","",
"1","3","CONNECTOR-2_MICROFIT_SMD_RIGHTANGLE_02_SINGLE_BLACK","J11","200","","","WM14310CT-ND","","Molex","538-43650-0214","0436500214","","","","","","","",
"1","3","CONNECTOR-2_μF_T_V_BLACK","J8","200","","","WM12762-ND","","Molex","538-43650-0217","436500217","","","","","","","",
"3","5","CONNECTOR-4_μF_S_RA_","J4, J5, J9","67","","","WM1832CT-ND","","Molex","538-0430450411","0430450411","","","","","","","",
"5","7","CONNECTOR-4_μF_T_V_BLACK","J2, J3, J7, J13, J15","40","","","2266-43045-0414-ND","","Molex","538-43045-0414","430450414","","","","","","","",
"1","3","CONNECTOR-6_μF_T_V_BLACK","J12","200","","","WM1797-ND","","Molex","538-43045-0614","430450614","","","","","","","",
"4","6","CONNECTOR-8_μF_T_V_BLACK","J1, J6, J14, J16","50","","","WM1798-ND","","Molex","538-43045-0814","430450814","","","","","","","",
"1","3","FUSE_HOLDER_MINIBLADESMD","XF1","200","","","36-3588-ND","MINI 297","Keystone Electronics","534-3588","3588","","","","","","","",
"6","16","JUMPER_0603_","JP4, JP5, JP5V, JP6, JP12V, JP24V","167","","","13-RC0603FR-130RLTR-ND","","YAGEO","603-RC0603FR-130RL","RC0603FR-130RL","","","","","","","",
"1","11","LED_0603_GREEN","D3","1000","","Green","754-1790-1-ND","","Kingbright","604-APT1608ZGCK","APT1608ZGCK","","","","","","","",
"1","11","LED_0603_RED","D1","1000","","Red","754-1786-1-ND","","Kingbright","604-APT1608SECKJ3PRV","APT1608SECK/J3-PRV","","","","","","","",
"1","11","LED_0603_YELLOW","D2","1000","","Yellow","754-1788-1-ND","","Kingbright","604-APT1608SYCK/J3-PRV","APT1608SYCK/J3-PRV","","","","","","","",
"2","4","LTC6820","U11, U12","100","","","","","Analog Devices","","LTC6820IMS#PBF","","","","","","","",
"1","3","MAX3075","U14","200","","","MAX3075EESA+-ND","","Analog Devices Inc.","700-MAX3075EESA","MAX3075EESA+","","","","","","","",
"1","3","MAX3227","U10","200","","","175-MAX3227EEAE/V+TCT-ND","","Analog Devices Inc.","700-MAX3227EAE","MAX3227EEAE/V+T","","","","","","","",
"1","3","MCP3208","U15","200","","","MCP3208T-BI/SLCT-ND","","Microchip Technology","579-MCP3208T-BI/SL","MCP3208T-BI/SL","","","","","","","",
"2","12","RESISTOR_0603_1.13K","R15, R17","500","","","P1.13KHCT-ND","","Panasonic Electronic Components","667-ERJ-3EKF1131V","ERJ-3EKF1131V","0.1W","1.13k","","1%","","75V","150V",
"2","12","RESISTOR_0603_1.33K","R14, R16","500","","","P1.33KDBCT-ND","","Panasonic Electronic Components","667-ERA-3AEB1331V","ERA-3AEB1331V","0.1W","1.33k","","0.1%","","11.53V","75V",
"4","14","RESISTOR_0603_120","R3, R18, R19, R20","250","","","P120DBCT-ND","","Panasonic Electronic Components","667-ERA-3AEB121V","ERA-3AEB121V","0.1W","120","","0.1%","","3.46V","75V",
"1","11","RESISTOR_0603_1K","R1","1000","","","1712-CPF-A-0603B1K0ETR-ND","","TE Connectivity Passive Product","279-CPF-A-0603B1K0E"," CPF-A-0603B1K0E","0.0625W","1k","","0.1%","","7.9V","50V",
"1","11","RESISTOR_0603_240","R2","1000","","","311-240HRCT-ND","","Yageo","603-RC0603FR-07240RL","RC0603FR-07240RL","0.1W","240","","1%","","4.90V","75V",
"2","12","RESISTOR_0603_2K","R12, R13","500","","","10-ERJ-UP3F2001VTR-ND","","Panasonic Electronic Components","667-ERJ-UP3F2001V","ERJ-UP3F2001V","0.25W","2k","","1%","","22.36V","150V",
"2","12","RESISTOR_0603_60.4","R21, R22","500","","","311-60.4HRCT-ND","","Yageo","603-RC0603FR-0760R4L","RC0603FR-0760R4L","0.1W","60.4","","1%","","2.48V","75V",
"8","18","RESISTOR_0603_8.35K","R4, R5, R6, R7, R8, R9, R10, R11","125","","","764-1461-2-ND","","Vishay Dale Thin Film","71-PTN0603E8351BST1","PTN0603E8351BST1","0.15W","8.35k","","0.1%","","28.90V","75V",
"1","3","TCAN1051HQV-Q1","U13","200","","","296-49935-1-ND","","Texas Instruments","595-TCAN1051HGVDQ1","TCAN1051HGVDRQ1","","","","","","","",
"1","3","TEENSY_4.0SM","A3","200","","","","","","","","","","4.0","","","","",
"17","19","TEST_POINT","3V3, 5V, 12V, CAN_H, CAN_L, CLK, GND, MISO, MOSI, RH_N, RH_P, RL_IM, RL_IP, RR_IM, RR_IP, RXD, TXD","12","","","36-5015CT-ND","","Keystone Electronics","534-5015","5015","","","","","","","",
"4","6","TVS_BIDIRECTIONAL_DUAL","D7, D9, D11, D12","50","","","296-25281-1-ND","","Texas Instruments","595-TPD2E007DCKR","TPD2E007DCKR","","","","","","","",
"2","4","TVS_BIDIRECTIONAL_DUALRS422","D8, D10","100","","","SM712CT-ND","","Semtech Corporation","947-SM712.TCT","SM712.TCT","","","","","","","",
"1","3","TVS_DO-214AA_30V","D6","200","","","118-1.5SMBJ30ATR-ND","","Bourns Inc.","652-1.5SMBJ30A"," 1.5SMBJ30A","","","","","30V","","",
"1","3","TVS_DO-219AB_14V","D4","200","","","SMF14A-E3-08GITR-ND","","Vishay General Semiconductor","78-SMF14A-E3-08","SMF14A-E3-08","","","","","14V","","",
"1","3","VOLTAGE_REGULATOR_MODULE_OKI-78SR_12V","A1","200","","","811-3293-ND","","Murata Power Solutions Inc.","580-OKI78SR12/1W36C","OKI-78SR-12/1.0-W36-C","","","","","","","",
"1","3","VOLTAGE_REGULATOR_MODULE_OKI-78SR_5V","A2","200","","","811-2196-5-ND","","Murata Power Solutions Inc.","580-OKI78SR5/1.5W36C","OKI-78SR-5/1.5-W36-C","","","","","","","",
"1","3","VOLTAGE_REGULATOR_SOT-223_3.3V","U1","200","","","LMS8117AMP-3.3/NOPBCT-ND","","Texas Instruments","926-LMS8117AMP33NOPB","LMS8117AMP-3.3/NOPB","","","","","","","",
