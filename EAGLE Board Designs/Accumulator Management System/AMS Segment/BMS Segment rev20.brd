# Repository hytech-racing/circuits-2024 (continued)

## EAGLE design EAGLE Board Designs/Testing and Practice Boards/Testing Boards/SAB Test Board rev 1.brd

Parts:
5V: TEST_POINT; 5015
!CAN_CS: TEST_POINT; 5015
+3V3: TEST_POINT; 5015
A: TEST_POINT; 5015
A1: TEENSY_4.0TH; TEENSY_SHORT
B: TEST_POINT; 5015
C1, C4, C13, C15, C17, C19, C27: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C2, C3: CAPACITOR_0603_10V_15PF; 0603-CAP
C5, C14, C18, C20, C26: CAPACITOR_0603_10V_1UF; 0603-CAP
CANH: TEST_POINT; 5015
CANL: TEST_POINT; 5015
D1: TVS_BIDIRECTIONAL_DUALRS422; SOT-23
D2: TVS_BIDIRECTIONAL_DUAL; SC-70-3
D3, D4: LED_0603_YELLOW; 0603-LED
D5: SCHOTTKY_1206_40V; 1206-DIODE
GEN_FILT: TEST_POINT; 5015
GEN_TO_T: JUMPER__1X02; 1X02
GND: TEST_POINT; 5015
J1, J6: CONNECTOR-4_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_04_DUAL
J2: CONNECTOR-8_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_08_DUAL
J4: CONNECTOR-6_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_06_DUAL
JP1, JP4, JP8, JP9: JUMPER__1X02; 1X02
LTCIN: TEST_POINT; 5015
LTCOUT: TEST_POINT; 5015
MISO: TEST_POINT; 5015
MOSI: TEST_POINT; 5015
R1, R2, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: RESISTOR_0603_10K; 0603-RES
R3, R11, R33: RESISTOR_0603_120; 0603-RES
R34: RESISTOR_0603_240; 0603-RES
R38, R39, R40, R41, R42, R43: RESISTOR_0603_4.22M; 0603-RES
SCK: TEST_POINT; 5015
U2: MCP2551; SOIC-08(NARROW,0.15")
U6: OPAMP_1_CHANNEL_OPA991; SC-70-5
U7: MAX3075; SOIC-08(NARROW,0.15")
U8: LTC1563; SSOP-16
U10: MCP2515; TSSOP-20
X1: CRYSTAL_16MHZ; ECX-42
XF1: FUSE_HOLDER_MINIBLADEPTH; 3568

Connections:
5VIN: D5.1 (A), J6.1
!CAN_CS: !CAN_CS.1, J2.5, U10.18 (!CS)
!CAN_INT: J2.6, U10.13 (!INT)
+3V3: +3V3.1, A1.3.3V, C13.1, C17.1, C18.1, C19.1, C20.1, C26.1, JP8.2, R2.1, R33.1, U7.8 (VCC), U8.16 (V+), U10.20 (VDD); also elsewhere on the board
+5V: 5V.1, A1.VIN, C4.1, C5.1, C14.1, C15.1, J1.1, J2.1, R34.1, U2.3 (VDD), XF1.3 (2), XF1.4 (2); also elsewhere on the board
A: A.1, D1.2 (C2), R11.1, U7.7 (B)
B: B.1, D1.1 (C1), JP1.2, U7.6 (A)
CANH: CANH.1, D2.2 (C2), J1.2, R3.1, U2.7 (CANH)
CANL: CANL.1, D2.1 (C1), J1.3, JP4.2, U2.6 (CANL)
DE/RE: A1.D2, U7.2 (!RE), U7.3 (DE)
FOURTH_ORDER_FILT: A1.D15 (A1); also elsewhere on the board
GEN_FILT_TEENSY: A1.D16 (A2), GEN_TO_T.2
GND: A1.AGND/GND (GND), A1.GND, C1.2, C2.2, C3.2, C4.2, C5.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C26.2, C27.2, D1.3 (A), D2.3 (A), D3.1 (C), D4.1 (C), GND.1, J1.4, J2.8, J4.6, J6.4, JP9.2, R1.1, R23.1, R24.1, R25.2, R27.1, R30.1, R31.1, U2.2 (GND), U6.2 (GND), U7.5 (GND), U8.3 (NC1), U8.5 (NC2), U8.8 (V-), U8.9 (!EN), U8.10 (NC5), U8.12 (NC4), U8.14 (NC3), U10.10 (GND), X1.2 (GND), X1.4 (GND); also elsewhere on the board
LPAIN: R40.2, R43.1, U8.6 (LPA)
LTCIN: J6.2, LTCIN.1, R42.1
LTCOUT: A1.D14 (A0), J6.3, LTCOUT.1, R38.1, U8.15 (LPB)
MISO: J2.3, MISO.1, U10.17 (SDO)
MOSI: J2.2, MOSI.1, U10.16 (SDI)
unnamed: C2.1, U10.9 (OSC1), X1.1
unnamed: C3.1, U10.8 (OSC2), X1.3
unnamed: R1.2, U2.8 (RS)
unnamed: JP4.1, R3.2
unnamed: R2.2, U10.19 (!RESET)
unnamed: D5.2 (C), XF1.1, XF1.2 (1)
unnamed: JP1.1, R11.2
unnamed: R22.1, R25.1, R28.2, R29.2, U6.4 (VOUT)
unnamed: JP8.1, JP9.1, U8.1 (!LP)
unnamed: R20.2, R32.1, U6.1 (VIN+)
unnamed: D3.2 (A), R33.2
unnamed: D4.2 (A), R34.2
unnamed: R26.2, R28.1
unnamed: R21.2, R26.1, R29.1, R30.2, R31.2, U6.3 (VIN-)
unnamed: C27.1, U8.7 (AGND)
unnamed: R39.1, U8.13 (INVB)
unnamed: R38.2, R39.2, R40.1, U8.11 (SB)
unnamed: R41.2, U8.4 (INVA)
unnamed: R41.1, R42.2, R43.2, U8.2 (SA)
P2: J4.2, R21.1, R27.2
P3: GEN_FILT.1, GEN_TO_T.1, J4.3, R22.2, R23.2, R24.2
P4: J4.4, R32.2
P5: J4.5, R20.1
RXCAN: U2.4 (RXD), U10.2 (RX)
RX_485: A1.D0 ((CRX1)D0), U7.1 (RO)
SCK: J2.4, SCK.1, U10.14 (CLK)
TXCAN: U2.1 (TXD), U10.1 (TX)
TX_485: A1.D1 ((CTX1)D1), U7.4 (DI)
VIN: C1.1, J4.1, U6.5 (VDD)
VREF: U2.5 (VREF)

Notes on the sheet:
Andrew Levine
CAN Bus (MCP2515 & MCP2551)
Teensy & MAX3075
LTC1563 @ 600Hz Butterworth
output to Teensy

Parts:
3.3_JMP, 4_TO_T: JUMPER__1X02; 1X02
3V3, 4_FILT_IN, 4_FILT_OUT: TEST_POINT; 5015
C7, C21: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C8, C9, C11, C12: CAPACITOR_0603_10V_10NF; 0603-CAP
C22, C23: CAPACITOR_0603_10V_22UF; 0603-CAP
C24: CAPACITOR_0603_10V_82PF; 0603-CAP
C25: CAPACITOR_0603_25V_10UF; 0603-CAP
CON_PWR: JUMPER__1X02; 1X02
J3: CONNECTOR-4_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_04_DUAL
JP3: JUMPER__1X02; 1X02
L1: INDUCTOR_PA4334_10UH; PA4334
R4: RESISTOR_0603_3.32K; 0603-RES
R12, R16: RESISTOR_0603_13K; 0603-RES
R13, R17: RESISTOR_0603_75K; 0603-RES
R14: RESISTOR_0603_0; 0603-RES
R15, R19: RESISTOR_0603_1K; 0603-RES
R35, R37: RESISTOR_0603_100K; 0603-RES
R36: RESISTOR_0603_22.1K; 0603-RES
U1: TPS54202DDCR; SOT-23-6
U9: OPAMP_2_CHANNEL_OPA_2991; SOT-23-8

Connections:
+3V3: 3.3_JMP.2, 3V3.1, JP3.2; also elsewhere on the board
+5V: C25.1, R37.2, U1.3 (VIN); also elsewhere on the board
EN: R37.1, U1.5 (EN)
FOURTH_ORDER_FILT: 4_TO_T.2; also elsewhere on the board
GND: C7.2, C9.2, C12.2, C22.2, C23.2, C25.2, J3.4, R15.1, R19.1, R36.1, U1.1 (GND), U9.4 (GND); also elsewhere on the board
unnamed: C9.1, R13.2, U9.5 (VIN+)
unnamed: C8.2, R12.2, R13.1
unnamed: R14.1, R15.2, U9.6 (VIN-)
unnamed: C21.1, U1.6 (BOOT)
unnamed: C12.1, R17.2, U9.3 (VIN+)
unnamed: C11.2, R16.2, R17.1
unnamed: C11.1, R4.2, R12.1, U9.1 (VOUT)
unnamed: R4.1, R19.2, U9.2 (VIN-)
unnamed: C24.2, R35.1, R36.2, U1.4 (FB)
unnamed: C22.1, C23.1, C24.1, JP3.1, L1.2, R35.2
unnamed: 3.3_JMP.1, C7.1, CON_PWR.1, U9.8 (VDD)
P7: CON_PWR.2, J3.1
P8: 4_FILT_IN.1, J3.2, R16.1
P9: 4_FILT_OUT.1, 4_TO_T.1, C8.1, J3.3, R14.2, U9.7 (VOUT)
SW: C21.2, L1.1, U1.2 (SW)

Notes on the sheet:
3.32k

Board: 2 copper layers, 101.6 x 65.7 mm, 109 parts (0 on the bottom side), 63 nets.

Other parts of the board:
U$1: LOGO_HYTECH_MEDIUM
U$3: LOGO_GT_MEDIUM

## EAGLE design EAGLE Board Designs/Accumulator Control Unit/Accumulator Control Unit rev6.brd

Parts:
3.3V: LED_0603_GREEN; 0603-LED
5V: LED_0603_BLUE; 0603-LED
12V: LED_0603_RED; 0603-LED
24V: LED_0603_ORANGE; 0603-LED
A1: VOLTAGE_REGULATOR_MODULE_OKI-78SR_12V; OKI-78SR
A2: VOLTAGE_REGULATOR_MODULE_OKI-78SR_5V; OKI-78SR
C1, C2, C3: CAPACITOR_0805_50V_10UF; 0805-CAP
C4: CAPACITOR_0603_25V_10UF; 0603-CAP
C5, C28: CAPACITOR_0603_10V_4.7UF; 0603-CAP
C6: CAPACITOR_0603_10V_1UF; 0603-CAP
C17: CAPACITOR_0603_10V_10NF; 0603-CAP
C26: CAPACITOR_0603_25V_0.1UF; 0603-CAP
C27, C43: CAPACITOR_0603_25V_1UF; 0603-CAP
CURRENT_REF: TEST_POINT; MICRO_MINIATURE
CURRENT_SENSE: TEST_POINT; MICRO_MINIATURE
CURRENT_SHUNT: CONNECTOR-4_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_04_DUAL
D2: TVS_DO-214AA_30V; DO-214AA
D9, D10: TVS__15V; SOT-23
D11: ZENER_1.5SMBJ_12V; 1.5SMBJ
EM: CONNECTOR-4_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_04_DUAL
F1, F2: FUSE_0603_.75A; 0603-FUSE
IMD: CONNECTOR-6_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_06_DUAL
J1: CONNECTOR-12_MF_T_V_; MOLEX_MICROFIT_PTH_VERTICAL_12_DUAL
J2: CONNECTOR-16_MF_T_V_; MOLEX_MICROFIT_PTH_VERTICAL_16_DUAL
Q3, Q4: TRANSISTOR_N_MOS__PMV15ENEA; SOT-23
Q5: TRANSISTOR_P_MOS_SOT-23_DMP3056L-7; SOT-23
R19: RESISTOR_0603_2.2K; 0603-RES
R46, R47, R69, R94: RESISTOR_0603_10K; 0603-RES
R49: RESISTOR_0603_3.3K; 0603-RES
R68: RESISTOR_0603_43K; 0603-RES
R70, R71: RESISTOR_0603_10; 0603-RES
R72, R74, R95: RESISTOR_0603_2K; 0603-RES
R73, R89, R96, R97: RESISTOR_0603_1K; 0603-RES
TP_3.3V, TP_5V, TP_12V, TP_24V: TEST_POINT; 5015
TP_GND: TEST_POINT; 5015
TP_TSAL_GREEN: TEST_POINT; MICRO_MINIATURE
TP_TSAL_RED: TEST_POINT; MICRO_MINIATURE
TSAL_GREEN: LED_0603_GREEN; 0603-LED
TSAL_RED: LED_0603_RED; 0603-LED
TSB: CONNECTOR-8_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_08_DUAL
U1: VOLTAGE_REGULATOR_SOT-223_3.3V; SOT-223
U15: LM555; SOIC-08(NARROW,0.15")
U27: ADG1423; MSOP-10
XF1: FUSE_HOLDER_MINIBLADEPTH; 3568

Connections:
24VIN: J2.1, Q5.3 (D)
60V_THRESHOLD: U27.6 (IN), U27.7 (IN); also elsewhere on the board
+3V3: 3.3V.2 (A), C5.1, CURRENT_SHUNT.1, TP_3.3V.1, U1.2 (OUT), U1.4 (OUT); also elsewhere on the board
+5V: 5V.2 (A), A2.3 (OUT), C4.1, C6.1, J1.3, TP_5V.1, U1.3 (IN); also elsewhere on the board
+12V: 12V.2 (A), A1.3 (OUT), C1.1, C26.1, C27.1, C43.1, J2.2, R69.2, R72.1, R95.1, TP_12V.1, U15.8 (VCC), U27.1 (S), U27.2 (S), U27.5 (VDD); also elsewhere on the board
+24V: 24V.2 (A), A1.1 (IN), A2.1 (IN), C2.1, C3.1, EM.1, IMD.1, J1.5, TP_24V.1, TSB.5, XF1.3 (2), XF1.4 (2); also elsewhere on the board
ACCUMULATOR_GND: IMD.5, J1.12
AIR2-: J1.11; also elsewhere on the board
AMS_OK: J2.6; also elsewhere on the board
BSPD_CURRENT: J2.14; also elsewhere on the board
BSPD_CURRENT_REF: J2.13; also elsewhere on the board
CANH: J2.3, J2.11; also elsewhere on the board
CANL: J2.4, J2.12; also elsewhere on the board
CHASSIS_GND: IMD.6, J2.16
CURRENT: CURRENT_SENSE.1, J1.6; also elsewhere on the board
CURRENT_REF: CURRENT_REF.1, J1.7; also elsewhere on the board
CURR_N: CURRENT_SHUNT.3; also elsewhere on the board
CURR_P: CURRENT_SHUNT.2; also elsewhere on the board
EM_CANH: EM.2; also elsewhere on the board
EM_CANL: EM.3; also elsewhere on the board
GND: A1.2 (GND), A2.2 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C17.2, C26.2, C27.2, C28.2, C43.2, CURRENT_SHUNT.4, D2.1 (A), D9.1 (A), D10.1 (A), EM.4, IMD.4, J1.2, J1.4, J1.9, J2.15, Q3.2 (S), Q4.2 (S), R19.1, R46.1, R47.2, R49.1, R73.1, R74.1, R89.1, R94.2, R96.1, R97.1, TP_GND.1, TSB.8, U1.1 (GND), U15.1 (GND), U27.4 (GND), U27.8 (GND); also elsewhere on the board
IMD_OK: J2.7; also elsewhere on the board
ISO_PACK+: TSB.2; also elsewhere on the board
ISO_PACK-: TSB.1; also elsewhere on the board
ISO_TS+: TSB.4; also elsewhere on the board
ISO_TS-: TSB.3; also elsewhere on the board
MHS: IMD.3, R19.2; also elsewhere on the board
unnamed: 3.3V.1 (C), R96.2
unnamed: 5V.1 (C), R73.2
unnamed: C28.1, R68.1, U15.2 (TRIGGER), U15.6 (THRESHOLD)
unnamed: C17.1, U15.5 (CONTROL)
unnamed: R68.2, R69.1, U15.7 (DISCHARGE)
unnamed: 12V.1 (C), R74.2
unnamed: D10.3 (C), R70.1, R94.1, TP_TSAL_GREEN.1, U27.9 (D)
unnamed: D9.3 (C), R47.1, R71.1, TP_TSAL_RED.1, U15.3 (OUTPUT)
unnamed: R95.2, TSAL_GREEN.2 (A)
unnamed: F1.1, J2.10
unnamed: F2.1, J2.9
unnamed: 24V.1 (C), R49.2
unnamed: R72.2, TSAL_RED.2 (A)
unnamed: Q3.1 (G), R71.2
unnamed: Q4.1 (G), R70.2
unnamed: D2.2 (C), D11.2 (C), Q5.2 (S), XF1.1, XF1.2 (1)
unnamed: D11.1 (A), Q5.1 (G), R89.2, R97.2
OKHS: IMD.2; also elsewhere on the board
PRECHARGE_OK: TSB.7; also elsewhere on the board
SHDN: J1.8, J1.10, J2.5, TSB.6
TIMER_EN: R46.2, U15.4 (!RESET), U27.10 (D)
TSAL_GREEN: F2.2, Q4.3 (D), TSAL_GREEN.1 (C)
TSAL_RED: F1.2, Q3.3 (D), TSAL_RED.1 (C)

Notes on the sheet:
Connectors
ACU to TSB connections
Power to ECU, CAN, TSAL, Shutdown Signals
Power Fusing and Regulation
SHDN connnects directly to AIR+, AIR- connects directly to GND
TSAL Circuitry
555 Timer Astable Mode Frequency: 3.529 Hz Duty Cycle: 50.57% Rules say 2-5Hz
SHDN connnects directly to AIR+
Current Sensor Accumulator GND, both AIR+ and -
IMD
Current Shunt
USE Higher watt rated

Parts:
AMS_OK: LED_0603_GREEN; 0603-LED
D3: TVS__8V; SOT-23
IMD_OK: LED_0603_ORANGE; 0603-LED
OKHS: LED_0603_YELLOW; 0603-LED
Q2: TRANSISTOR_N_MOS__PMV15ENEA; SOT-23
R3, R20: RESISTOR_0603_20K; 0603-RES
R4, R21: RESISTOR_0603_5.1K; 0603-RES
R5: RESISTOR_0603_10K; 0603-RES
R6: RESISTOR_0603_10; 0603-RES
R17: RESISTOR_0603_2.2K; 0603-RES
R18, R25, R48: RESISTOR_0603_2K; 0603-RES
TP_AMS_OK: TEST_POINT; MICRO_MINIATURE
TP_IMD_OK: TEST_POINT; MICRO_MINIATURE
U2, U3: RELAY_SOLIDSTATE_NO_DIP-4; DIP-4

Connections:
+24V: R4.2, U2.4 (CONTACT2), U3.4 (CONTACT2); also elsewhere on the board
AMS_OK: AMS_OK.2 (A), R3.2, TP_AMS_OK.1, U2.3 (CONTACT1); also elsewhere on the board
AMS_OK_3.3V: D3.3 (C), R5.1, R6.1; also elsewhere on the board
GND: D3.1 (A), Q2.2 (S), R3.1, R5.2, R17.1, R18.1, R20.1, R25.1, R48.1, U3.2 (CONTROL-); also elsewhere on the board
IMD_OK: IMD_OK.2 (A), R20.2, TP_IMD_OK.1, U3.3 (CONTACT1); also elsewhere on the board
unnamed: R21.2, U3.1 (CONTROL+)
unnamed: OKHS.1 (C), R18.2
unnamed: R4.1, U2.1 (CONTROL+)
unnamed: AMS_OK.1 (C), R48.2
unnamed: Q2.3 (D), U2.2 (CONTROL-)
unnamed: IMD_OK.1 (C), R25.2
unnamed: Q2.1 (G), R6.2
OKHS: OKHS.2 (A), R17.2, R21.1; also elsewhere on the board

Notes on the sheet:
Josh Kirshenbaum
Shutdown Signal Buffering/Amplification

Parts:
C14, C15, C23, C24, C25, C38, C39, C40, C41, C42: CAPACITOR_0603_10V_0.1UF; 0603-CAP
D1: TVS__8V; SOT-23
K1: RELAY_SOLIDSTATE_NO_DIP-4; DIP-4
PACK+_OUT_TEST: TEST_POINT; MICRO_MINIATURE
PC_OK: TEST_POINT; MICRO_MINIATURE
PRECHARGE_OK: LED_0603_RED; 0603-LED
Q1: TRANSISTOR_N_MOS__PMV15ENEA; SOT-23
R1: RESISTOR_0603_10; 0603-RES
R2, R55, R56, R57, R61, R62, R66, R67, R86, R87, R88, R91: RESISTOR_0603_10K; 0603-RES
R24, R65, R83: RESISTOR_0603_1K; 0603-RES
R33, R34, R37, R38: RESISTOR_0603_18.7K_LT; 0603-RES
R35, R36, R39, R40: RESISTOR_0603_43K_LT; 0603-RES
R52, R60, R64, R85: RESISTOR_0603_DNP; 0603-RES
R53: RESISTOR_0603_5.9K; 0603-RES
R54: RESISTOR_0603_11.5K; 0603-RES
R58: RESISTOR_0603_36.5K; 0603-RES
R59: RESISTOR_0603_330K; 0603-RES
R63, R84: RESISTOR_0603_14K; 0603-RES
R90: RESISTOR_0603_73.2K; 0603-RES
R92: RESISTOR_0603_1M; 0603-RES
R93: RESISTOR_0603_8.66K; 0603-RES
R135: RESISTOR_0603_470; 0603-RES
TS+_OUT_TEST: TEST_POINT; MICRO_MINIATURE
U8, U9, U11, U12, U13, U22, U26: OPAMP_1_CHANNEL_OPA991; SC-70-5
U23, U24, U25: LOGICGATE_AND_DCK3; SC-70-5

Connections:
0.90X_DIV: R58.1, R59.2, R60.2, U12.3 (VIN-)
0.525V_DIV: R90.1, R92.2, R93.2, U26.3 (VIN-)
3.305V_DIV: R52.2, R53.1, R54.2, U11.3 (VIN-)
4.66V_DIV_A: R63.2, R64.1, R65.1, U13.1 (VIN+)
4.66V_DIV_B: R83.1, R84.2, R85.1, U22.1 (VIN+)
60V_THRESHOLD: R91.2, U26.4 (VOUT); also elsewhere on the board
+5V: C14.1, C15.1, C23.1, C24.1, C25.1, C38.1, C39.1, C40.1, C41.1, C42.1, K1.4 (CONTACT2), R53.2, R64.2, R65.2, R83.2, R85.2, R90.2, U8.5 (VDD), U9.5 (VDD), U11.5 (VDD), U12.5 (VDD), U13.5 (VDD), U22.5 (VDD), U23.5 (VDD), U24.5 (VDD), U25.5 (VDD), U26.5 (VDD); also elsewhere on the board
AIR2-: Q1.3 (D); also elsewhere on the board
GND: C14.2, C15.2, C23.2, C24.2, C25.2, C38.2, C39.2, C40.2, C41.2, C42.2, D1.1 (A), K1.2 (CONTROL-), PRECHARGE_OK.1 (C), Q1.2 (S), R2.2, R36.2, R39.2, R52.1, R54.1, R56.1, R57.1, R59.1, R60.1, R61.1, R63.1, R66.1, R67.1, R84.1, R86.1, R87.1, R88.1, R91.1, R92.1, R93.1, U8.2 (GND), U9.2 (GND), U11.2 (GND), U12.2 (GND), U13.2 (GND), U22.2 (GND), U23.3 (GND), U24.3 (GND), U25.3 (GND), U26.2 (GND); also elsewhere on the board
HV+_OUT_OK: R87.2, U23.4 (OUT), U25.2 (IN2)
ISO_PACK+: R33.1, R55.2; also elsewhere on the board
ISO_PACK-: R34.1, R55.1; also elsewhere on the board
ISO_TS+: R37.1, R62.2; also elsewhere on the board
ISO_TS-: R38.1, R62.1; also elsewhere on the board
unnamed: PRECHARGE_OK.2 (A), R24.1
unnamed: Q1.1 (G), R1.2
unnamed: R37.2, R39.1, U9.1 (VIN+)
unnamed: R38.2, R40.1, U9.3 (VIN-)
unnamed: R33.2, R36.1, U8.1 (VIN+)
unnamed: R34.2, R35.1, U8.3 (VIN-)
unnamed: K1.1 (CONTROL+), R135.1
unnamed: R135.2, U25.4 (OUT)
PACK+_OUT: PACK+_OUT_TEST.1, R35.2, R57.2, R58.2, U8.4 (VOUT), U11.1 (VIN+), U22.3 (VIN-); also elsewhere on the board
PRECHARGE+_OUT_OK: R88.2, U24.4 (OUT), U25.1 (IN1)
PRECHARGE_OK: D1.3 (C), K1.3 (CONTACT1), PC_OK.1, R1.1, R2.1, R24.2; also elsewhere on the board
PRECHARGE_REACHED: R61.2, U12.4 (VOUT), U24.2 (IN2)
TS+_OUT: R40.2, R66.2, TS+_OUT_TEST.1, U9.4 (VOUT), U12.1 (VIN+), U13.3 (VIN-), U26.1 (VIN+); also elsewhere on the board
TS+_OUT_OV_OK: R67.2, U13.4 (VOUT), U24.1 (IN1)
V_PACK_REF_OV_OK: R86.2, U22.4 (VOUT), U23.1 (IN1)
V_PACK_REF_UV_OK: R56.2, U11.4 (VOUT), U23.2 (IN2)

Notes on the sheet:
60V threshold check
low side switches shutdown current across precharge relay
Josh Kirshenbaum
AIR2- Low Side Switching with PRECHARGE_OK
550V corresponds to 4.816V out of difference op amp
OV fault at 533V
UV fault at 377V
Trips at 59.95V
TSB Outputs: TS: 533V -> 2.02954V TS: 377V -> 1.43553V
OPA991 Gain: 43k/18.7k = 2.2994652
OPA991 Outputs: TS/P: 533V -> 4.66686V TS/P: 377V -> 3.30095V
