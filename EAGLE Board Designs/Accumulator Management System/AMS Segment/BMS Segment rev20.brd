# Repository hytech-racing/circuits-2024

File README.md:

# 2024 Circuits

Repository for all of the circuits for the 2023-2024 car.

## Getting Started with this Git Repository
1. Follow HyTech's [Software Guide](https://github.com/hytech-racing/training/tree/master/Resources).
2. Create a GitHub account if you don't already have one.
3. Download and install [GitHub Desktop](https://desktop.github.com/) (basic) or [Git CLI](https://git-scm.com/book/en/v2/Getting-Started-Installing-Git) (advanced).
    * If you are using GitHub Desktop for the first time, be sure to read the [User Guide](https://help.github.com/desktop/guides/).
    * If you are using Git for the first time, you should start off by reading a tutorial. There are many available online:
        * [Pro Git book](https://git-scm.com/book/en/v2)
        * [Atlassian Git Tutorial](https://www.atlassian.com/git/tutorials/)
    * You may want to keep a copy of [GitHub's Git Cheat Sheet](https://services.github.com/kit/downloads/github-git-cheat-sheet.pdf) as a reference.
4. Talk to your subteam lead to be added to the team within the GitHub organization.
5. Clone this repository to your computer using the URLs:
    * SSH: `git@github.com:hytech-racing/circuits-2024.git`
    * HTTPS: `https://github.com/hytech-racing/circuits-2024.git`

## Getting Started with EAGLE
1. Follow HyTech's [Software Guide](https://github.com/hytech-racing/training/tree/master/Resources).
2. Download and install [EAGLE](https://www.autodesk.com/products/eagle/overview)
3. Get the free [Educational License](https://www.autodesk.com/education/free-software/eagle) (a .edu email address is required)

## Github Software Guidelines and Electrical Designs Rules Review Process
Follow HyTech's [Github Software Guidelines](https://gtvault.sharepoint.com/:w:/r/sites/HyTechRacing2/Shared%20Documents/Electrical%20-%20All/HT06/Guidelines%20Rules%20and%20Procedures/Github%20Software%20Guidelines.docx?d=w7e0d7e36afeb47b5a935bd7a4851bceb&csf=1&web=1&e=sudzjV) to understand our development flow and pull request procedure.
Follow HyTech's [Electrical Designs Rules Review Process](https://gtvault.sharepoint.com/:w:/r/sites/HyTechRacing2/Shared%20Documents/Electrical%20-%20All/HT06/Guidelines%20Rules%20and%20Procedures/Electrical%20Designs%20Rules%20Review%20Process.docx?d=w0277498dfb4b4b9fbfad0e5db8a187c8&csf=1&web=1&e=LDFCNz) to understand circuit design flow. 

## Circuit Board Versioning Scheme
* New boards must start their numbering at revision 1.
* Revision numbers must be incremented by 1 when a physical board is manufactured, but not at any other time.
* After a board is manufactured, the files corresponding to the manufactured version should not be modified.
* Circuit boards based off of a previous year's design should increment based off of the previous board's revision number.

## More Information
* [Software Guide](https://github.com/hytech-racing/training/tree/master/Resources)
* [Team Site](https://hytechracing.gatech.edu/)
* [Facebook](https://www.facebook.com/HyTechRacing/)
* [Engage](https://gatech.campuslabs.com/engage/organization/hytech-racing)

## License
This project is licensed under the GPL License v3.0. See the [LICENSE](LICENSE) file for more information.

## EAGLE design EAGLE Board Designs/Accumulator Management System/AMS Segment/BMS Segment rev20.brd

Board: 4 copper layers, 275.2 x 93.9 mm, 343 parts (29 on the bottom side), 220 nets.

Parts:
C1, C2, C6, C7, C8, C23, C26, C27: CAPACITOR_0603_10V_1UF; 0603-CAP
C3, C4, C5, C13, C14, C19, C20, C28, C29, C32: CAPACITOR_0603_100V_10NF; 0603-CAP
C9, C25: CAPACITOR_0603_10V_22UF; 0603-CAP
C10, C24: CAPACITOR_0603_100V_0.1UF; 0603-CAP
C11, C22: CAPACITOR_1206_100V_2.2UF; 1206-CAP
C12, C21: CAPACITOR_0805_100V_0.22UF; 0805-CAP
C15, C16, C17, C18, C33, C34, C35, C40: CAPACITOR_0603_10V_10NF; 0603-CAP
CELL1:C1, CELL2:C1, CELL3:C1, CELL4:C1, CELL5:C1, CELL6:C1, CELL7:C1, CELL8:C1, CELL9:C1, CELL10:C1, CELL11:C1, CELL12:C1, CELL13:C1, CELL14:C1, CELL15:C1, CELL16:C1, CELL17:C1, CELL18:C1, CELL19:C1, CELL20:C1, CELL21:C1: CAPACITOR_0603_100V_10NF; 0603-CAP
CELL1:D1, CELL2:D1, CELL3:D1, CELL4:D1, CELL5:D1, CELL6:D1, CELL7:D1, CELL8:D1, CELL9:D1, CELL10:D1, CELL11:D1, CELL12:D1, CELL13:D1, CELL14:D1, CELL15:D1, CELL16:D1, CELL17:D1, CELL18:D1, CELL19:D1, CELL20:D1, CELL21:D1: LED_0603_RED; 0603-LED
CELL1:Q1, CELL2:Q1, CELL3:Q1, CELL4:Q1, CELL5:Q1, CELL6:Q1, CELL7:Q1, CELL8:Q1, CELL9:Q1, CELL10:Q1, CELL11:Q1, CELL12:Q1, CELL13:Q1, CELL14:Q1, CELL15:Q1, CELL16:Q1, CELL17:Q1, CELL18:Q1, CELL19:Q1, CELL20:Q1, CELL21:Q1: TRANSISTOR_P_MOS_SOT23_SI2369DS-T1-GE3; SOT-23
CELL1:R1, CELL2:R1, CELL3:R1, CELL4:R1, CELL5:R1, CELL6:R1, CELL7:R1, CELL8:R1, CELL9:R1, CELL10:R1, CELL11:R1, CELL12:R1, CELL13:R1, CELL14:R1, CELL15:R1, CELL16:R1, CELL17:R1, CELL18:R1, CELL19:R1, CELL20:R1, CELL21:R1: RESISTOR_0603_100; 0603-RES
CELL1:R2, CELL1:R4, CELL2:R2, CELL2:R4, CELL3:R2, CELL3:R4, CELL4:R2, CELL4:R4, CELL5:R2, CELL5:R4, CELL6:R2, CELL6:R4, CELL7:R2, CELL7:R4, CELL8:R2, CELL8:R4, CELL9:R2, CELL9:R4, CELL10:R2, CELL10:R4, CELL11:R2, CELL11:R4, CELL12:R2, CELL12:R4, CELL13:R2, CELL13:R4, CELL14:R2, CELL14:R4, CELL15:R2, CELL15:R4, CELL16:R2, CELL16:R4, CELL17:R2, CELL17:R4, CELL18:R2, CELL18:R4, CELL19:R2, CELL19:R4, CELL20:R2, CELL20:R4, CELL21:R2, CELL21:R4: RESISTOR_0603_1K; 0603-RES
CELL1:R3, CELL2:R3, CELL3:R3, CELL4:R3, CELL5:R3, CELL6:R3, CELL7:R3, CELL8:R3, CELL9:R3, CELL10:R3, CELL11:R3, CELL12:R3, CELL13:R3, CELL14:R3, CELL15:R3, CELL16:R3, CELL17:R3, CELL18:R3, CELL19:R3, CELL20:R3, CELL21:R3: RESISTOR_PWR263_7.5; PWR263
D1, D2, D3, D4: LED_0603_BLUE; 0603-LED
F1, F2, F3, F4, F5, F6, F7, F8, F9, F10, F11, F12, F13, F14, F15, F16, F17, F18, F19, F20, F21, F22, F23: FUSE__; BMS-FUSE-UNIVERSAL
J1, J2, J3, J4, J6, J8, J9, J10, J11, J12: CONNECTOR-2_MICROFIT_SMD_RIGHTANGLE_02_SINGLE_BLA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; MOLEX_MICROFIT_SMD_RIGHTANGLE_02_SINGLE
J100, J101, J102, J103, J104, J105, J106, J107, J108, J109, J110, J111, J112, J113, J114, J115, J116, J117, J118, J119, J120, J121: CONNECTOR-1_5222_; 5222
L1, L2: INDUCTOR_74451133_33UH; 74451133
R1, R2: RESISTOR_0603_0; 0603-RES
R3, R5, R14, R20, R30, R38, R45, R50: RESISTOR_0603_2.74K; 0603-RES
R4, R6, R7, R13, R15, R22, R31, R35, R44, R46, R47, R51: RESISTOR_0603_100; 0603-RES
R8, R41: RESISTOR_0603_470; 0603-RES
R9, R16, R17, R21, R32, R39, R42, R43: RESISTOR_0603_1K; 0603-RES
R10, R40: RESISTOR_0603_374K; 0603-RES
R11, R12, R23, R24, R62, R69: RESISTOR_0603_DNP; 0603-RES
R18, R19: RESISTOR_0603_210; 0603-RES
R56, R57, R63, R64, R65, R66, R67, R68: RESISTOR_0603_49.9; 0603-RES
T2: TRANSFORMER_HM2112ZNLT; HM2112ZNLT
T3: ACM2012-361-2P-T002; ACM2012
TP1, TP2, TP3, TP4, TP7, TP8, TP9, TP10: TEST_POINT; MICRO_MINIATURE
U2, U5: LTC6811-1; SSOP-48
U3, U4: LT3990-5; MSOP-16(MSE)
U6, U7: MCP9701T-E/LT; SOT-23-3
U$1, U$5, U$6, U$7, U$18, U$20, U$23, U$25: HV_0.50"
U$2, U$3, U$4, U$8, U$11, U$12, U$17, U$21, U$22, U$24: MOUNTING_M4
U$9, U$16: HV_1.00"
U$10: LOGO_GT_MEDIUM
U$13, U$14: DANGER_HIGH_VOLTAGE
U$15: NUMBER
U$19: LOGO_HYTECH_LARGE
U$26: LOGO_HYTECH_SQUARE_EXTRA_LARGE
U$27, U$28, U$29, U$31, U$32, U$33: FIDUCIAL_1MM
U$101, U$102, U$103: HV_LARGE

Connections:
C0L: C5.1, R7.2, U2.26
C0U: C28.1, R47.2, U5.26
C1L: CELL1:C1.1, CELL1:R1.2, U2.24
C1U: CELL13:C1.1, CELL13:R1.2, U5.24
C2L: CELL2:C1.1, CELL2:R1.2, U2.22
C2U: CELL14:C1.1, CELL14:R1.2, U5.22
C3L: CELL3:C1.1, CELL3:R1.2, U2.20
C3U: CELL15:C1.1, CELL15:R1.2, U5.20
C4L: CELL4:C1.1, CELL4:R1.2, U2.18
C4U: CELL16:C1.1, CELL16:R1.2, U5.18
C5L: CELL5:C1.1, CELL5:R1.2, U2.16
C5U: CELL17:C1.1, CELL17:R1.2, U5.16
C6L: CELL6:C1.1, CELL6:R1.2, U2.14
C6U: CELL18:C1.1, CELL18:R1.2, U5.14
C7L: CELL7:C1.1, CELL7:R1.2, U2.12
C7U: CELL19:C1.1, CELL19:R1.2, U5.12
C8L: CELL8:C1.1, CELL8:R1.2, U2.10
C8U: CELL20:C1.1, CELL20:R1.2, U5.10
C9L: CELL9:C1.1, CELL9:R1.2, U2.8
C9U: CELL21:C1.1, CELL21:R1.2, U5.2, U5.4, U5.6, U5.8
C10L: CELL10:C1.1, CELL10:R1.2, U2.6
C11L: CELL11:C1.1, CELL11:R1.2, U2.4
C12L: CELL12:C1.1, CELL12:R1.2, U2.2
CC0: F1.1, J100.1
CC1: F4.1, J101.1
CC2: F2.1, J102.1
CC3: F5.1, J103.1
CC4: F3.1, J104.1
CC5: F9.1, J105.1
CC6: F6.1, J106.1
CC7: F10.1, J107.1
CC8: F7.1, J108.1
CC9: F11.1, J109.1
CC10: F8.1, J110.1
CC11: F13.1, J111.1
CC12: F12.1, F15.1, J112.1
CC13: F14.1, J113.1
CC14: F17.1, J114.1
CC15: F16.1, J115.1
CC16: F19.1, J116.1
CC17: F18.1, J117.1
CC18: F21.1, J118.1
CC19: F20.1, J119.1
CC20: F22.1, J120.1
CC21: F23.1, J121.1
CELL1:LED: CELL1:D1.1, CELL1:R4.2
CELL1:QD: CELL1:D1.2, CELL1:Q1.3, CELL1:R3.2
CELL1:QG: CELL1:Q1.1, CELL1:R2.1
CELL2:LED: CELL2:D1.1, CELL2:R4.2
CELL2:QD: CELL2:D1.2, CELL2:Q1.3, CELL2:R3.2
CELL2:QG: CELL2:Q1.1, CELL2:R2.1
CELL3:LED: CELL3:D1.1, CELL3:R4.2
CELL3:QD: CELL3:D1.2, CELL3:Q1.3, CELL3:R3.2
CELL3:QG: CELL3:Q1.1, CELL3:R2.1
CELL4:LED: CELL4:D1.1, CELL4:R4.2
CELL4:QD: CELL4:D1.2, CELL4:Q1.3, CELL4:R3.2
CELL4:QG: CELL4:Q1.1, CELL4:R2.1
CELL5:LED: CELL5:D1.1, CELL5:R4.2
CELL5:QD: CELL5:D1.2, CELL5:Q1.3, CELL5:R3.2
CELL5:QG: CELL5:Q1.1, CELL5:R2.1
CELL6:LED: CELL6:D1.1, CELL6:R4.2
CELL6:QD: CELL6:D1.2, CELL6:Q1.3, CELL6:R3.2
CELL6:QG: CELL6:Q1.1, CELL6:R2.1
CELL7:LED: CELL7:D1.1, CELL7:R4.2
CELL7:QD: CELL7:D1.2, CELL7:Q1.3, CELL7:R3.2
CELL7:QG: CELL7:Q1.1, CELL7:R2.1
CELL8:LED: CELL8:D1.1, CELL8:R4.2
CELL8:QD: CELL8:D1.2, CELL8:Q1.3, CELL8:R3.2
CELL8:QG: CELL8:Q1.1, CELL8:R2.1
CELL9:LED: CELL9:D1.1, CELL9:R4.2
CELL9:QD: CELL9:D1.2, CELL9:Q1.3, CELL9:R3.2
CELL9:QG: CELL9:Q1.1, CELL9:R2.1
CELL10:LED: CELL10:D1.1, CELL10:R4.2
CELL10:QD: CELL10:D1.2, CELL10:Q1.3, CELL10:R3.2
CELL10:QG: CELL10:Q1.1, CELL10:R2.1
CELL11:LED: CELL11:D1.1, CELL11:R4.2
CELL11:QD: CELL11:D1.2, CELL11:Q1.3, CELL11:R3.2
CELL11:QG: CELL11:Q1.1, CELL11:R2.1
CELL12:LED: CELL12:D1.1, CELL12:R4.2
CELL12:QD: CELL12:D1.2, CELL12:Q1.3, CELL12:R3.2
CELL12:QG: CELL12:Q1.1, CELL12:R2.1
CELL13:LED: CELL13:D1.1, CELL13:R4.2
CELL13:QD: CELL13:D1.2, CELL13:Q1.3, CELL13:R3.2
CELL13:QG: CELL13:Q1.1, CELL13:R2.1
CELL14:LED: CELL14:D1.1, CELL14:R4.2
CELL14:QD: CELL14:D1.2, CELL14:Q1.3, CELL14:R3.2
CELL14:QG: CELL14:Q1.1, CELL14:R2.1
CELL15:LED: CELL15:D1.1, CELL15:R4.2
CELL15:QD: CELL15:D1.2, CELL15:Q1.3, CELL15:R3.2
CELL15:QG: CELL15:Q1.1, CELL15:R2.1
CELL16:LED: CELL16:D1.1, CELL16:R4.2
CELL16:QD: CELL16:D1.2, CELL16:Q1.3, CELL16:R3.2
CELL16:QG: CELL16:Q1.1, CELL16:R2.1
CELL17:LED: CELL17:D1.1, CELL17:R4.2
CELL17:QD: CELL17:D1.2, CELL17:Q1.3, CELL17:R3.2
CELL17:QG: CELL17:Q1.1, CELL17:R2.1
CELL18:LED: CELL18:D1.1, CELL18:R4.2
CELL18:QD: CELL18:D1.2, CELL18:Q1.3, CELL18:R3.2
CELL18:QG: CELL18:Q1.1, CELL18:R2.1
CELL19:LED: CELL19:D1.1, CELL19:R4.2
CELL19:QD: CELL19:D1.2, CELL19:Q1.3, CELL19:R3.2
CELL19:QG: CELL19:Q1.1, CELL19:R2.1
CELL20:LED: CELL20:D1.1, CELL20:R4.2
CELL20:QD: CELL20:D1.2, CELL20:Q1.3, CELL20:R3.2
CELL20:QG: CELL20:Q1.1, CELL20:R2.1
CELL21:LED: CELL21:D1.1, CELL21:R4.2
CELL21:QD: CELL21:D1.2, CELL21:Q1.3, CELL21:R3.2
CELL21:QG: CELL21:Q1.1, CELL21:R2.1
DRVL: TP1.1, U2.38, U3.4
DRVU: TP9.1, U4.4, U5.38
GPIO1L: C14.1, R22.2, U2.27
GPIO1U: C32.2, R51.1, U5.27
GPIO2L: C13.1, R15.2, U2.28
GPIO2U: C29.1, R46.2, U5.28
GPIO3L: C4.1, R6.2, U2.29
GPIO3U: C20.1, R35.2, U5.29
GPIO4L: C3.2, R4.2, U2.32
GPIO4U: C19.1, R31.2, U5.32
GPIO5L: R2.1, U2.33
GPIO5U: R1.1, U5.33
IAL_N: R57.2, T2.9, U2.42
IAL_P: R67.1, T2.7, U2.41
IAU_N: C16.2, R65.1, U5.41
IAU_N_CHOKED: C16.1, R12.1, T3.P$3
IAU_P: C15.2, R64.2, U5.42
IAU_P_CHOKED: C15.1, R12.2, T3.P$4
IBL_N: R11.1, R66.1, T3.P$2, U2.47
IBL_P: R11.2, R63.2, T3.P$1, U2.48
IBU_N: R68.1, T2.10, U5.47
IBU_P: R56.2, T2.12, U5.48
IIN_N: J12.2, R69.2, T2.4
IIN_P: J12.1, R69.1, T2.6
IOUT_N: J11.1, R62.1, T2.3
IOUT_P: J11.2, R62.2, T2.1
unnamed: R40.2, U4.16
unnamed: D1.2, R9.1
unnamed: C21.2, L2.1, U4.9
unnamed: C21.1, U4.11
unnamed: D3.2, R32.1
unnamed: D2.2, R21.1
unnamed: R10.2, U3.16
unnamed: R16.1, R17.1, U2.46
unnamed: D4.2, R39.1
unnamed: C12.2, L1.1, U3.9
unnamed: C12.1, U3.11
unnamed: C1.1, R18.1, U6.1
unnamed: R42.1, R43.1, U5.46
unnamed: C2.1, R19.1, U7.1
unnamed: C33.2, T2.11
unnamed: C34.2, T2.8
unnamed: R43.2, U5.45
unnamed: R16.2, U2.45
unnamed: J10.2, R50.1, R51.2
unnamed: J9.2, R45.1, R46.1
unnamed: J8.2, R35.1, R38.1
unnamed: J6.2, R30.1, R31.1
unnamed: J4.2, R20.1, R22.1
unnamed: J3.2, R14.1, R15.1
unnamed: J2.2, R5.1, R6.1
unnamed: J1.2, R3.2, R4.1
S1L: CELL1:R2.2, U2.25
S1U: CELL13:R2.2, U5.25
S2L: CELL2:R2.2, U2.23
S2U: CELL14:R2.2, U5.23
S3L: CELL3:R2.2, U2.21
S3U: CELL15:R2.2, U5.21
S4L: CELL4:R2.2, U2.19
S4U: CELL16:R2.2, U5.19
S5L: CELL5:R2.2, U2.17
S5U: CELL17:R2.2, U5.17
S6L: CELL6:R2.2, U2.15
S6U: CELL18:R2.2, U5.15
S7L: CELL7:R2.2, U2.13
S7U: CELL19:R2.2, U5.13
S8L: CELL8:R2.2, U2.11
S8U: CELL20:R2.2, U5.11
S9L: CELL9:R2.2, U2.9
S9U: CELL21:R2.2, U5.9
S10L: CELL10:R2.2, U2.7
S11L: CELL11:R2.2, U2.5
S12L: CELL12:R2.2, U2.3
SENSE1: CELL1:Q1.2, CELL1:R1.1, CELL2:R3.1, CELL2:R4.1, F4.2
SENSE2: CELL2:Q1.2, CELL2:R1.1, CELL3:R3.1, CELL3:R4.1, F2.2
SENSE3: CELL3:Q1.2, CELL3:R1.1, CELL4:R3.1, CELL4:R4.1, F5.2
SENSE4: CELL4:Q1.2, CELL4:R1.1, CELL5:R3.1, CELL5:R4.1, F3.2
SENSE5: CELL5:Q1.2, CELL5:R1.1, CELL6:R3.1, CELL6:R4.1, F9.2
SENSE6: CELL6:Q1.2, CELL6:R1.1, CELL7:R3.1, CELL7:R4.1, F6.2
SENSE7: CELL7:Q1.2, CELL7:R1.1, CELL8:R3.1, CELL8:R4.1, F10.2
SENSE8: CELL8:Q1.2, CELL8:R1.1, CELL9:R3.1, CELL9:R4.1, F7.2
SENSE9: CELL9:Q1.2, CELL9:R1.1, CELL10:R3.1, CELL10:R4.1, F11.2
SENSE10: CELL10:Q1.2, CELL10:R1.1, CELL11:R3.1, CELL11:R4.1, F8.2
SENSE11: CELL11:Q1.2, CELL11:R1.1, CELL12:R3.1, CELL12:R4.1, F13.2
SENSE12: CELL12:Q1.2, CELL12:R1.1, F12.2, R8.1, R13.2
SENSE13: CELL13:Q1.2, CELL13:R1.1, CELL14:R3.1, CELL14:R4.1, F14.2
SENSE14: CELL14:Q1.2, CELL14:R1.1, CELL15:R3.1, CELL15:R4.1, F17.2
SENSE15: CELL15:Q1.2, CELL15:R1.1, CELL16:R3.1, CELL16:R4.1, F16.2
SENSE16: CELL16:Q1.2, CELL16:R1.1, CELL17:R3.1, CELL17:R4.1, F19.2
SENSE17: CELL17:Q1.2, CELL17:R1.1, CELL18:R3.1, CELL18:R4.1, F18.2
SENSE18: CELL18:Q1.2, CELL18:R1.1, CELL19:R3.1, CELL19:R4.1, F21.2
SENSE19: CELL19:Q1.2, CELL19:R1.1, CELL20:R3.1, CELL20:R4.1, F20.2
SENSE20: CELL20:Q1.2, CELL20:R1.1, CELL21:R3.1, CELL21:R4.1, F22.2
SENSE21: CELL21:Q1.2, CELL21:R1.1, F23.2, R41.1, R44.1
SHUNT_H_IN: C17.1, R63.1, R66.2
SHUNT_H_OUT: C35.2, R56.1, R68.2
SHUNT_L_IN: C40.2, R57.1, R67.2
SHUNT_L_OUT: C18.1, R64.1, R65.2
TOUTL: R2.2, R24.2, U7.2
TOUTU: R1.2, R23.2, U6.2
V+L: C10.1, R13.1, TP2.1, U2.1
V+U: C24.1, R44.2, TP10.1, U5.1
V-L: C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C17.2, C34.1, C40.1, CELL1:C1.2, CELL1:R3.1, CELL1:R4.1, CELL2:C1.2, CELL3:C1.2, CELL4:C1.2, CELL5:C1.2, CELL6:C1.2, CELL7:C1.2, CELL8:C1.2, CELL9:C1.2, CELL10:C1.2, CELL11:C1.2, CELL12:C1.2, D1.1, D2.1, F1.2, R3.1, R5.2, R7.1, R10.1, R14.2, R17.2, R20.2, R24.1, TP3.1, U2.30, U2.31, U3.8, U3.17, U7.3
V-U: C1.2, C18.2, C19.2, C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C32.1, C33.1, C35.1, CELL13:C1.2, CELL13:R3.1, CELL13:R4.1, CELL14:C1.2, CELL15:C1.2, CELL16:C1.2, CELL17:C1.2, CELL18:C1.2, CELL19:C1.2, CELL20:C1.2, CELL21:C1.2, D3.1, D4.1, F15.2, R23.1, R30.2, R38.2, R40.1, R42.2, R45.2, R47.1, R50.2, TP7.1, U4.8, U4.17, U5.30, U5.31, U6.3
VINL: C11.1, R8.2, U3.6
VINU: C22.1, R41.2, U4.6
VREF1L: C7.1, U2.35
VREF1U: C26.1, U5.35
VREF2L: C6.1, U2.34
VREF2U: C27.1, U5.34
VREGL: C8.1, C9.1, J1.1, J2.1, J3.1, J4.1, L1.2, R9.2, R19.2, R21.2, TP4.1, U2.36, U2.37, U2.40, U3.1, U3.2, U3.13
VREGU: C23.1, C25.1, J6.1, J8.1, J9.1, J10.1, L2.2, R18.2, R32.2, R39.2, TP8.1, U4.1, U4.2, U4.13, U5.36, U5.37, U5.40

## EAGLE design EAGLE Board Designs/Tractive System Board/Tractive System Board Rev7.brd

Parts:
C1, C9: CAPACITOR_0603_25V_0.1UF; 0603-CAP
C2: CAPACITOR_0603_50V_47PF; 0603-CAP
C3: CAPACITOR_1206_630V_10NF; 1206-CAP
C4, C6: CAPACITOR_0603_25V_4.7UF; 0603-CAP
C5: CAPACITOR_0603_25V_10UF; 0603-CAP
C7: CAPACITOR_0805_50V_10UF; 0805-CAP
C8: CAPACITOR_0603_100V_0.1UF; 0603-CAP
C10, C12: CAPACITOR_0603_50V_10NF; 0603-CAP
C11, C13, C15, C16, C17, C18: CAPACITOR_0603_25V_1UF; 0603-CAP
C14: CAPACITOR_1812_1000V_0.1UF; 1812-CAP
C19, C22: CAPACITOR_0603_10V_1UF; 0603-CAP
C20, C21: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C28: CAPACITOR_ELECTROLYTIC_A759KR_180UF; A759KR
CV1: CAPACITOR_VALUE; 0603-CAP
D1, D101: SCHOTTKY_DO-214AA_150V; DO-214AA
D2: RECTIFIER_800V_SOD-123FA; SOD-123FA
D102: ZENER_DO-214AA_100V; DO-214AA
D103: RECTIFIER_1000V_SMA; SMA
EN/UVLO: TEST_POINT; 5015
LED_+12V: LED_0603_GREEN; 0603-LED
PACK_DIV_OUT: TEST_POINT; 5015
Q1: TRANSISTOR_N_MOS_POWERFLAT5X6_STL2N80K5; POWERFLAT5X6
R1: RESISTOR_0603_1K; 0603-RES
R2: RESISTOR_0603_0.02; 0603-RES
R3, R6, R7: RESISTOR_0603_10K; 0603-RES
R4: RESISTOR_0603_10; 0603-RES
R5: RESISTOR_0603_93.1K; 0603-RES
R8, R14, R16, R17: RESISTOR_0805_HV75K; 0805-RES
R9, R11, R21, R22, R37, R38: RESISTOR_0805_HV365K; 0805-RES
R10, R19: RESISTOR_0805_HV1M; 0805-RES
R12: RESISTOR_0603_20K; 0603-RES
R15, R18: RESISTOR_0603_; 0603-RES
R36, R42: RESISTOR_0603_DNP; 0603-RES
R39: RESISTOR_0805_HV330K; 0805-RES
R40, R41: RESISTOR_1206_HV46.4K; 1206-RES
T1: TRANSFORMER(3W); PQ2620
TS+10V, TS+12V: TEST_POINT; 5015
TS-FUSED: TEST_POINT; 5015
TS_DIV_OUT: TEST_POINT; 5015
U1: VOLTAGE_REGULATOR_SOT-223_10V; SOT-223
U2: LT8316; TSSOP-20(16)
U3, U4: ISO224B_AIRGAP; SOIC-08(WIDE,0.295")-AIRGAP

Connections:
+5V: C19.1, C20.1, C21.1, C22.1, U3.8 (VDD2), U4.8 (VDD2); also elsewhere on the board
EN/UVLO: EN/UVLO.1, R39.1, R40.2, R41.2, R42.1, U2.17 (EN/UVLO)
GND: C19.2, C20.2, C21.2, C22.2, U3.5 (GND2), U4.5 (GND2); also elsewhere on the board
IP+: U4.7 (OUTP); also elsewhere on the board
IP-: U4.6 (OUTN); also elsewhere on the board
IT+: U3.7 (OUTP); also elsewhere on the board
IT-: U3.6 (OUTN); also elsewhere on the board
unnamed: R21.2, R22.1
unnamed: R9.1, R11.2
unnamed: D102.2 (C), D103.C
unnamed: R10.2, R11.1
unnamed: R19.2, R21.1
unnamed: D103.A, Q1.D, T1.1
unnamed: C4.1, D1.2 (C), U2.9 (BIAS)
unnamed: R5.1, R6.2, U2.12 (FB)
unnamed: C2.2, R3.2
unnamed: R3.1, U2.10 (DCM)
unnamed: R7.2, U2.13 (VC)
unnamed: R12.2, U2.14 (IREG)
unnamed: C2.1, D1.1 (A), R5.2, T1.5
unnamed: C9.1, R7.1
unnamed: C6.1, R42.2, U2.8 (INTVCC)
unnamed: R4.1, U2.19 (GATE)
unnamed: D101.1 (A), R36.1, T1.8 (8,9), T1.9 (8,9)
unnamed: LED_+12V.2 (A), R1.1
unnamed: Q1.S, R2.2, U2.18 (SENSE)
unnamed: Q1.G, R4.2
unnamed: CV1.2, R36.2
unnamed: R37.1, R38.2
unnamed: R38.1, R39.2
unnamed: C3.1, D2.C, R37.2
unnamed: C10.1, R18.2, U4.2 (IN)
unnamed: C12.1, R15.2, U3.2 (IN)
unnamed: C17.1, U4.1 (VCAP)
unnamed: C16.1, U3.1 (VCAP)
PACK+FUSED: R22.2; also elsewhere on the board
PACK_DIV_OUT: PACK_DIV_OUT.1, R16.2, R17.2, R18.1, R19.1
TS+10V: C5.1, C11.1, C13.1, C15.1, C18.1, TS+10V.1, U1.2 (OUT), U1.4 (OUT), U3.3 (VDD1), U4.3 (VDD1)
TS+12V: C1.1, C7.1, C8.1, C28.PLUS, CV1.1, D101.2 (C), R1.2, TS+12V.1, U1.3 (IN); also elsewhere on the board
TS+FUSED: C14.1, D2.A, D102.1 (A), R9.2, T1.3, U2.1 (VIN), U2.2 (VIN), U2.3 (VIN); also elsewhere on the board
TS-FUSED: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C28.MINUS, LED_+12V.1 (C), R2.1, R6.1, R8.1, R12.1, R14.1, R16.1, R17.1, R40.1, R41.1, T1.6, T1.10 (10,11), T1.11 (10,11), TS-FUSED.1, U1.1 (GND), U2.15 (GND), U2.16 (SMODE), U2.20 (GND), U2.THERMAL, U3.4 (GND1), U4.4 (GND1); also elsewhere on the board
TS_DIV_OUT: R8.2, R10.1, R14.2, R15.1, TS_DIV_OUT.1

Notes on the sheet:
Precharger Power Stage
Precharger Isoamps
TS+FUSED > 60V EN/UVLO > 1.285V @ 50C

Parts:
+5V, +24V: TEST_POINT; 5015
A1: VOLTAGE_REGULATOR_MODULE_OKI-78SR_5V; OKI-78SR
C23, C25: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C24: CAPACITOR_0603_25V_10UF; 0603-CAP
C26: CAPACITOR_0603_50V_0.1UF; 0603-CAP
C27: CAPACITOR_0603_50V_1UF; 0603-CAP
D3, D4: LED_0603_BLUE; 0603-LED
D5: LED_0603_ORANGE; 0603-LED
D6: LED_0603_GREEN; 0603-LED
D7: TVS__8V; SOT-23
D8: LED_0603_YELLOW; 0603-LED
D100: SCHOTTKY_SOD323_60V; SOD-323
F1, F2: FUSE_HOLDER_122; 122
GND: TEST_POINT; 5015
IP+: TEST_POINT; 5015
IP-: TEST_POINT; 5015
IT+: TEST_POINT; 5015
IT-: TEST_POINT; 5015
J1: CONNECTOR-5_MICRO_V7S_; MOLEX_MICROFIT_PTH_VERTICAL_07_SINGLE_SPACED
J2: CONNECTOR-5_MICRO_V6S_; MOLEX_MICROFIT_PTH_VERTICAL_06_SINGLE_SPACED
J3: CONNECTOR-8_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_08_DUAL
K1: RELAY_SPST_NO_D_24; D
PACK+: TEST_POINT; 5015
PACK+FUSED: TEST_POINT; 5015
PRECHARGE_OK: TEST_POINT; 5015
Q2: TRANSISTOR_N_MOS__PMV15ENEA; SOT-23
R13, R23: RESISTOR_B20-SHORTENED_1.5K; B20-SHORTENED
R20: RESISTOR_0603_DNP; 0603-RES
R24: RESISTOR_0603_39; 0603-RES
R25, R27: RESISTOR_0603_2K; 0603-RES
R26, R29, R31: RESISTOR_0603_1K; 0603-RES
R28: RESISTOR_0603_10K; 0603-RES
R30: RESISTOR_0603_3.3K; 0603-RES
R32: RESISTOR_0603_75K; 0603-RES
R33: RESISTOR_0603_10; 0603-RES
R34: RESISTOR_0805_1M; 0805-RES
R35: RESISTOR_0805_523K; 0805-RES
SHDN: TEST_POINT; 5015
TS-UNFUSED: TEST_POINT; 5015
U5: RELAY_SOLIDSTATE_NO_AB38S-Q-AIRGAP; SOP-04-AIRGAP
U10: LTC6994-2; SOT-23-6

Connections:
+5V: +5V.1, A1.3 (OUT), C23.1, C24.1, C25.1, R26.1, R35.2, U10.5 (V+); also elsewhere on the board
+24V: +24V.1, A1.1 (IN), C26.1, C27.1, J3.1, R25.2
DCDC_ENABLE: D7.3 (C), R28.2, R31.2, R33.1, U10.4 (OUT)
GND: A1.2 (GND), C23.2, C24.2, C25.2, C26.2, C27.2, D3.1 (C), D4.1 (C), D5.1 (C), D6.1 (C), D7.1 (A), D8.1 (C), GND.1, J3.4, Q2.2 (S), R28.1, R32.1, R34.1, U5.2 (CONTROL-), U10.2 (GND); also elsewhere on the board
IP+: IP+.1, J3.5; also elsewhere on the board
IP-: IP-.1, J3.6; also elsewhere on the board
IT+: IT+.1, J3.7; also elsewhere on the board
IT-: IT-.1, J3.8; also elsewhere on the board
LED+: J2.3, R20.2
unnamed: D5.2 (A), R27.1
unnamed: Q2.1 (G), R33.2
unnamed: R32.2, U10.3 (SET)
unnamed: R34.2, R35.1, U10.6 (DIV)
unnamed: D6.2 (A), R29.1
unnamed: D8.2 (A), R31.1
unnamed: D3.2 (A), R25.1
unnamed: D4.2 (A), R26.2
unnamed: D100.A, K1.3 (COIL-), Q2.3 (D)
unnamed: K1.1 (CONTACT2), R13.1, R23.1
unnamed: R30.2, U5.1 (CONTROL+)
unnamed: R24.1, U5.3 (CONTACT1)
PACK+: J1.5, K1.2 (CONTACT1), PACK+.1, U5.4 (CONTACT2)
PACK+FUSED: PACK+FUSED.1, R24.2; also elsewhere on the board
PRECHARGE_OK: J3.3, PRECHARGE_OK.1, R29.2, U10.1 (IN)
SHDN: D100.C, J3.2, K1.4 (COIL+), R27.2, R30.1, SHDN.1
TS+12V: R20.1; also elsewhere on the board
TS+FUSED: F1.3 (2), F1.4 (2), J1.4; also elsewhere on the board
TS+UNFUSED: F1.1, F1.2 (1), J1.1, J1.2, R13.2, R23.2
TS-FUSED: F2.3 (2), F2.4 (2), J2.1, J2.2; also elsewhere on the board
TS-UNFUSED: F2.1, F2.2 (1), J2.5, TS-UNFUSED.1

Notes on the sheet:
PACK+ Optoisolator
Precharge Relay
Discharge Relay Moved to Separate Board
TS Fusing
Power Regulation
Shunt resistor rated to 50 mA

Notes on the sheet:
10A Mini-Blade Fuse
Molex Microfit 4-pin
Molex Microfit 6-pin, spaced
Molex Microfit 7-pin, spaced

Board: 4 copper layers, 209.3 x 74.0 mm, 144 parts (18 on the bottom side), 62 nets.

Other parts of the board:
$$U$1, $$U$4, $$U$6, $$U$8, $$U$104, $$U$105, $$U$106, $$U$107: HV_MEDIUM
$$U$2, $$U$3, $$U$5: MOUNTING_M3
U$7: DANGER_HIGH_VOLTAGE
U$9, U$13, U$14, U$15, U$100, U$101, U$102, U$103: HV_MEDIUM
U$10: LOGO_HYTECH_MEDIUM
U$11, U$12, U$16, U$17: MOUNTING_M3
U$18: LOGO_GT_MEDIUM
