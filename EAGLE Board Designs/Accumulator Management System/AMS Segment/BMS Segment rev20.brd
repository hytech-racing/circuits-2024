# Repository hytech-racing/circuits-2024 (continued)

## EAGLE design EAGLE Board Designs/Tractive System Board/Tractive System Board Rev8.brd

Board: 4 copper layers, 200.0 x 65.0 mm, 144 parts (16 on the bottom side), 72 nets.

Parts:
$$U$1, $$U$4, $$U$6, $$U$8, $$U$104, $$U$105, $$U$106, $$U$107: HV_MEDIUM
+5V, +24V: TEST_POINT; 5015
A1: VOLTAGE_REGULATOR_MODULE_OKI-78SR_5V; OKI-78SR
ACU: CONNECTOR-8_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_08_DUAL
C3: CAPACITOR_2220_35V_47UF; 2220-CAP
C23, C25: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C24, C32, C33: CAPACITOR_0603_25V_10UF; 0603-CAP
C26, C37, C42, C46, C51: CAPACITOR_0603_50V_0.1UF; 0603-CAP
C27: CAPACITOR_0603_50V_1UF; 0603-CAP
C30: CAPACITOR_0603_25V_47NF; 0603-CAP
C31, C38, C44, C47: CAPACITOR_1206_50V_1NF; 1206-CAP
C35: CAPACITOR_1812_1000V_0.1UF; 1812-CAP
C36, C45: CAPACITOR_1206_25V_1UF; 1206-CAP
C39, C48: CAPACITOR_1206_50V_0.1UF; 1206-CAP
C40, C49: CAPACITOR_0603_25V_1UF; 0603-CAP
C41, C50: CAPACITOR_0603_50V_1NF; 0603-CAP
C43, C52: CAPACITOR_0603_100V_10NF; 0603-CAP
C54: CAPACITOR_1206_630V_47PF; 1206-CAP
C55: CAPACITOR_1206_630V_10NF; 1206-CAP
C56: CAPACITOR_0603_50V_10NF; 0603-CAP
D2: SCHOTTKY_SOD323_30VV; SOD-323
D3, D4: LED_0603_BLUE; 0603-LED
D5: LED_0603_ORANGE; 0603-LED
D6: LED_0603_GREEN; 0603-LED
D7: TVS__8V; SOT-23
D8: LED_0603_YELLOW; 0603-LED
D9, D10, D11: RECTIFIER_800V_SOD-123FA; SOD-123FA
D12: ZENER_SMB(DO-214AA)_13V; SMB(DO-214AA)
D100: SCHOTTKY_SOD323_60V; SOD-323
EN/UVLO: TEST_POINT; 5015
F1, F2: FUSE_HOLDER_122; 122
GND: TEST_POINT; 5015
IP+: TEST_POINT; 5015
IP-: TEST_POINT; 5015
IT+: TEST_POINT; 5015
IT-: TEST_POINT; 5015
K1: RELAY_SPST_NO_D_24; D
L1: INDUCTOR_SRR0745A_1MH; SRR0745A-102M
LED_+12V1: LED_0603_GREEN; 0603-LED
PACK+: TEST_POINT; 5015
PACK+FUSED: TEST_POINT; 5015
PACK_HLDO: TEST_POINT; 5015
PACK_INP: TEST_POINT; 5015
PACK_ISO_DIAG: TEST_POINT; 5015
PRECHARGE_OK: TEST_POINT; 5015
Q2: TRANSISTOR_N_MOS__PMV15ENEA; SOT-23
R1, R20, R42: RESISTOR_0603_DNP; 0603-RES
R13, R23: RESISTOR_B20-SHORTENED_1.5K; B20-SHORTENED
R15: RESISTOR_0603_14K; 0603-RES
R18: RESISTOR_0603_1.65K; 0603-RES
R24: RESISTOR_0603_39; 0603-RES
R25, R27: RESISTOR_0603_2K; 0603-RES
R26, R29, R31, R50: RESISTOR_0603_1K; 0603-RES
R28: RESISTOR_0603_10K; 0603-RES
R30: RESISTOR_0603_3.3K; 0603-RES
R32: RESISTOR_0603_75K; 0603-RES
R33: RESISTOR_0603_10; 0603-RES
R34: RESISTOR_0805_1M; 0805-RES
R35: RESISTOR_0805_523K; 0805-RES
R40: RESISTOR_0603_22.1K; 0603-RES
R41: RESISTOR_0805_HV330K; 0805-RES
R45, R46, R52, R53, R57, R58: RESISTOR_0805_HV365K; 0805-RES
R47, R48: RESISTOR_1206_HV46.4K; 1206-RES
R49: RESISTOR_0603_5.9K; 0603-RES
R51: RESISTOR_0603_0.12; 0603-RES
R54, R59: RESISTOR_0805_HV1M; 0805-RES
R55, R60: RESISTOR_0603_HV3.3K; 0603-RES
R56, R61: RESISTOR_1206_HV4.99K; 1206-RES
SHDN: TEST_POINT; 5015
TS+: CONNECTOR-5_MICRO_V7S_; MOLEX_MICROFIT_PTH_VERTICAL_07_SINGLE_SPACED
TS+12V: TEST_POINT; 5015
TS-: CONNECTOR-5_MICRO_V6S_; MOLEX_MICROFIT_PTH_VERTICAL_06_SINGLE_SPACED
TS-FUSED: TEST_POINT; 5015
TS-UNFUSED: TEST_POINT; 5015
TS_HLDO: TEST_POINT; 5015
TS_INP: TEST_POINT; 5015
TS_ISO_DIAG: TEST_POINT; 5015
U5: RELAY_SOLIDSTATE_NO_AB38S-Q-AIRGAP; SOP-04-AIRGAP
U6: LT8315; TSSOP-20(16)
U7, U8: AMC3330_AIRGAP; SOIC-16W-AIRGAP
U10: LTC6994-2; SOT-23-6
U$2, U$6, U$17, U$22: MOUNTING_M4
U$7: DANGER_HIGH_VOLTAGE
U$8, U$9, U$13, U$14, U$15, U$16, U$100, U$101, U$102, U$103: HV_MEDIUM
U$10: LOGO_HYTECH_MEDIUM
U$11, U$12: MOUNTING_M3
U$18: LOGO_GT_MEDIUM

Connections:
+5V: +5V.1, A1.3, C23.1, C24.1, C25.1, C31.1, C36.1, C44.1, C45.1, R26.1, R35.2, U7.12, U8.12, U10.5; also elsewhere on the board
+24V: +24V.1, A1.1, ACU.1, C26.1, C27.1, R25.2
AIL+: R20.1, TS-.3
DCDC_ENABLE: D7.3, R28.2, R31.2, R33.1, U10.4
EN/UVLO: EN/UVLO.1, R1.2, R41.1, R47.2, R48.2, U6.17
FB: R15.1, R18.2, U6.12
GND: A1.2, ACU.4, C23.2, C24.2, C25.2, C26.2, C27.2, C31.2, C36.2, C37.2, C44.2, C45.2, C46.2, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, GND.1, Q2.2, R28.1, R32.1, R34.1, U5.2, U7.9, U7.15, U8.9, U8.15, U10.2; also elsewhere on the board
INTVCC: C33.1, R1.1, U6.8
IP+: ACU.5, IP+.1, U8.11
IP-: ACU.6, IP-.1, U8.10
IREG/SS: R49.2, U6.14
IT+: ACU.7, IT+.1, U7.11
IT-: ACU.8, IT-.1, U7.10
LED+: R20.2; also elsewhere on the board
unnamed: R41.2, R46.1
unnamed: D5.2, R27.1
unnamed: Q2.1, R33.2
unnamed: R45.1, R46.2
unnamed: R32.2, U10.3
unnamed: R34.2, R35.1, U10.6
unnamed 25: R42.2; also elsewhere on the board
unnamed: D6.2, R29.1
unnamed 28: R1.1; also elsewhere on the board
unnamed: D8.2, R31.1
unnamed: D3.2, R25.1
unnamed: D4.2, R26.2
unnamed: C37.1, U7.13, U7.16
unnamed: R56.1, R61.2
unnamed: C54.1, R56.2
unnamed: C54.2, U6.10
unnamed: D100.A, K1.3, Q2.3
unnamed: C30.1, R40.1
unnamed: LED_+12V1.2, R50.1
unnamed: C55.1, D10.C, R45.2
unnamed: C32.1, D2.C, U6.9
unnamed: K1.1, R13.1, R23.1
unnamed: C40.1, C41.1, C42.2, U7.1, U7.3
unnamed: C46.1, U8.13, U8.16
unnamed: R30.2, R42.2, U5.1
unnamed: C56.1, D2.A, D9.C, R15.2
unnamed: R24.1, U5.3
unnamed: R52.2, R53.1
unnamed: R53.2, R54.1
unnamed: C49.1, C50.1, C51.2, U8.1, U8.3
unnamed: R57.2, R58.1
unnamed: R58.2, R59.1
PACK+: K1.2, PACK+.1, TS+.5, U5.4
PACK+FUSED: PACK+FUSED.1, R24.2, R59.2; also elsewhere on the board
PACK_HLDO_OUT: C47.1, C48.1, PACK_HLDO.1, U8.5
PACK_INP: C52.1, PACK_INP.1, R57.1, R60.2, U8.6
PACK_ISO_DIAG: PACK_ISO_DIAG.1, U8.14
PGND: C30.2, C32.2, C33.2, C55.2, C56.2, D11.C, L1.2, R18.1, R47.1, R48.1, R49.1, R51.1, U6.15, U6.16, U6.20, U6.THERMAL
PRECHARGE_OK: ACU.3, PRECHARGE_OK.1, R29.2, U10.1
SHDN: ACU.2, D100.C, K1.4, R27.2, R30.1, R42.1, SHDN.1
SOURCE: R51.2, U6.18
TS+12V: TS+12V.1; also elsewhere on the board
TS+FUSED: C35.1, D10.A, F1.3, F1.4, R54.2, R61.1, TS+.4, U6.1, U6.2, U6.3
TS+UNFUSED: F1.1, F1.2, R13.2, R23.2, TS+.1, TS+.2
TS-FUSED: C3.2, C35.2, C38.2, C39.2, C40.2, C41.2, C42.1, C43.2, C47.2, C48.2, C49.2, C50.2, C51.1, C52.2, D11.A, D12.A, F2.3, F2.4, LED_+12V1.1, R55.1, R60.1, TS-.1, TS-.2, TS-FUSED.1, U7.2, U7.7, U7.8, U8.2, U8.7, U8.8; also elsewhere on the board
TS-UNFUSED: F2.1, F2.2, TS-.5, TS-UNFUSED.1
TS_HLDO_OUT: C38.1, C39.1, TS_HLDO.1, U7.5
TS_INP: C43.1, R52.1, R55.2, TS_INP.1, U7.6
TS_ISO_DIAG: TS_ISO_DIAG.1, U7.14
VC: R40.2, U6.13

## EAGLE design EAGLE Board Designs/Corner Board/Corner Board Rev4updated.brd

Parts:
C3: CAPACITOR_0603_25V_1UF; 0603-CAP
C4: CAPACITOR_0603_35V_0.1UF; 0603-CAP
C5: CAPACITOR_0603_35V_1UF; 0603-CAP
C9, C10: CAPACITOR_0805_50V_10UF; 0805-CAP
C11: CAPACITOR_0603_50V_10NF; 0603-CAP
C16, C17: CAPACITOR_0603_10V_1UF; 0603-CAP
C18, C19: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C20: CAPACITOR_0603_10V_15PF; 0603-CAP
J1: CONNECTOR-8_AMPHENOL_M12A_08PMMP_; M12A-08PMMP
J2: CONNECTOR-2_MICROFIT_SMD_RIGHTANGLE_02_SINGLE_BLA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; MOLEX_MICROFIT_SMD_RIGHTANGLE_02_SINGLE
J3: BINDER-M12-A_4_PIN; BINDER-86-0531-1120-00004M12
J4: CONNECTOR-4_μF_S_RA_; MOLEX_MICROFIT_SMD_RIGHTANGLE_04_DUAL
R9: RESISTOR_0603_1.33K; 0603-RES
R10: RESISTOR_0603_120; 0603-RES
R13: RESISTOR_0603_1.13K; 0603-RES
R22: RESISTOR_0603_2K; 0603-RES
T1: 78613/3C_78613/3C_AIRGAP; 78613/3C_AIRGAP
U6: VOLTAGE_REFERENCE_SOIC-8_10V; SOIC-08(NARROW,0.15")
U7: VOLTAGE_REGULATOR_SOT-223_3.3V; SOT-223
U10: LTC6820; MSOP-16
U11: MCP3204; SOIC-14

Connections:
10V: C3.1, J3.1, U6.6 (OUT)
+3V3: C10.1, C16.1, C17.1, C18.2, C19.2, R22.2, U7.2 (OUT), U7.4 (OUT), U10.1 (EN), U10.6 (VLOGIC), U10.9 (VDD), U11.13 (VREF), U11.14 (VDD); also elsewhere on the board
+5V: C9.1, J1.2, U7.3 (IN)
+24V: C4.1, C5.1, C11.1, J1.1, J4.1, U6.2 (VIN); also elsewhere on the board
ADC_CLK: U10.4 (CLK), U11.11 (CLK)
ADC_CS: U10.5 (!CS), U11.8 (!CS!/SHDN)
ADC_SDI: R22.1, U10.2 (SDI), U11.9 (SDI)
ADC_SDO: U10.3 (SDO), U11.10 (SDO)
DIFF_N: J1.6, T1.4 (SEC_1)
DIFF_P: J1.5, T1.6 (SEC_2)
GND: C3.2, C4.2, C5.2, C9.2, C10.2, C11.2, C16.2, C17.2, C18.1, C19.1, C20.2, J1.8, J3.2, J4.4, R13.2, U6.4 (GND), U7.1 (GND), U10.7 (POL), U10.8 (PHA), U10.12 (MSTR), U10.13 (SLOW), U10.14 (GND), U11.7 (GND), U11.12 (AGND); also elsewhere on the board
LOAD_CELL_FILTERED: U11.3 (CH2); also elsewhere on the board
unnamed: C20.1, T1.2 (PRI_CENTER_TAP)
unnamed: R9.1, U10.16 (IBIAS)
unnamed: R9.2, R13.1, U10.15 (ICMP)
OUT_N: R10.1, T1.3 (PRI_2), U10.10 (IM)
OUT_P: R10.2, T1.1 (PRI_1), U10.11 (IP)
POSTINTERLOCK: J1.4, J2.1
PREINTERLOCK: J1.3, J2.2
SIGNAL_N: J3.4; also elsewhere on the board
SIGNAL_P: J3.3; also elsewhere on the board
SUS_POT_1: J4.2; also elsewhere on the board
SUS_POT_1_3V3: U11.2 (CH1); also elsewhere on the board

Notes on the sheet:
.9 mA bias current = 18 mA drive current.
.184 W absorbed
isoSPI circuitry
ADC circuitry
Power stage
Connectors

Parts:
C1: CAPACITOR_0603_25V_0.1UF; 0603-CAP
C2, C15: CAPACITOR_0603_35V_0.1UF; 0603-CAP
C6, C14: CAPACITOR_0603_10V_10NF; 0603-CAP
C21: CAPACITOR_0603_35V_1UF; 0603-CAP
C22: CAPACITOR_0603_35V_0.47UF; 0603-CAP
JP1, JP2, JP3, JP4: JUMPER_0603_; 0603-RES
R1: RESISTOR_0603_1K; 0603-RES
R2: RESISTOR_0603_1.13K; 0603-RES
R3, R6, R7, R8, R14: RESISTOR_0603_20K; 0603-RES
R4: RESISTOR_0603_2.74K; 0603-RES
R5, R17: RESISTOR_0603_1.5M; 0603-RES
R11: RESISTOR_0603_12K; 0603-RES
R12: RESISTOR_0603_7.5K; 0603-RES
R15: RESISTOR_0603_DNP; 0603-RES
R18: RESISTOR_0603_1.24K; 0603-RES
R19: RESISTOR_0603_10K; 0603-RES
U1, U4: OPAMP_2_CHANNEL_OPA_2991; SOT-23-8
U3: INA823DT; SOIC-08(NARROW,0.15")

Connections:
+3V3: C1.1, U1.8 (VDD); also elsewhere on the board
+24V: C2.1, C15.1, U3.7 (VDD), U4.8 (VDD); also elsewhere on the board
GND: C1.2, C2.2, C6.1, C14.1, C15.2, C22.2, R1.1, R14.1, R17.1, R18.2, U1.4 (GND), U3.4 (GND), U3.5 (VREF), U4.4 (GND); also elsewhere on the board
LOAD_CELL_AMPLIFIED: R2.2, R8.1, U1.1 (VOUT)
LOAD_CELL_FILTERED: R14.2, U1.6 (VIN-), U1.7 (VOUT); also elsewhere on the board
LOAD_CELL_POST_INA: R7.1, U3.6 (VOUT)
unnamed: R1.2, R2.1, U1.2 (VIN-)
unnamed: R4.2, U3.1 (RG1)
unnamed: R3.1, R7.2
unnamed: R4.1, U3.8 (RG2)
unnamed: C6.2, R3.2, U1.3 (VIN+)
unnamed: JP3.2, JP4.1, R5.1, R15.1, U3.2 (VIN-)
unnamed: R6.1, R8.2
unnamed: JP1.2, JP2.1, R5.2, R15.2, U3.3 (VIN+)
unnamed: C14.2, R6.2, U1.5 (VIN+)
unnamed: C21.1, R19.1, U4.6 (VIN-), U4.7 (VOUT)
unnamed: C22.1, R12.2, U4.5 (VIN+)
unnamed: C21.2, R11.2, R12.1
SIGNAL_N: JP2.2, JP4.2; also elsewhere on the board
SIGNAL_P: JP1.1, JP3.1; also elsewhere on the board
SUS_POT_1: R17.2, U4.3 (VIN+); also elsewhere on the board
SUS_POT_1_3V3: R18.1, R19.2; also elsewhere on the board
SUS_POT_1_24V1: R11.1, U4.1 (VOUT), U4.2 (VIN-)

Notes on the sheet:
37.5x gain
4.32x gain
162x gain total
Gain = 1 + 100K/R
0.11 gain
add CAP in place of R5 from rev3 if signal is too distorted.
SUS Pots
Load Cells

Board: 4 copper layers, 64.8 x 64.9 mm, 59 parts (34 on the bottom side), 38 nets.

Other parts of the board:
U$1, U$2, U$3, U$7: MOUNTING_M3
U$4: LOGO_HYTECH_SMALL
U$6: LOGO_GT_SMALL

## EAGLE design EAGLE Board Designs/Testing and Practice Boards/Keychain/keychain_rev4.brd

Parts:
C1, C3: CAPACITOR_0603_10V_10NF; 0603-CAP
C2: CAPACITOR_0603_10V_4.7UF; 0603-CAP
D1, D2, D3, D4, D5, D6: LED_0603_RED; 0603-LED
J1: USB4110
R1: RESISTOR_0603_18.7K; 0603-RES
R2: RESISTOR_0603_41.2K; 0603-RES
R3: RESISTOR_0603_10; 0603-RES
R4, R5: RESISTOR_0603_5.1K; 0603-RES
U1: LM555; SOIC-08(NARROW,0.15")

Connections:
+5V: C3.1, J1.P$2 (VBUS), J1.P$11 (VBUS), R1.2, U1.4 (!RESET), U1.8 (VCC)
GND: C1.2, C2.2, C3.2, J1.P$1 (GND), J1.P$12 (GND), J1.S$1 (SHELL), J1.S$2 (SHELL), J1.S$3 (SHELL), J1.S$4 (SHELL), R3.1, R4.1, R5.1, U1.1 (GND)
unnamed: C1.1, U1.5 (CONTROL)
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), U1.3 (OUTPUT)
unnamed: D1.1 (C), D2.1 (C), D3.1 (C), D4.1 (C), D5.1 (C), D6.1 (C), R3.2
unnamed: J1.P$4 (CC1), R4.2
unnamed: J1.P$10 (CC2), R5.2
unnamed: C2.1, R2.1, U1.2 (TRIGGER), U1.6 (THRESHOLD)
unnamed: R1.1, R2.2, U1.7 (DISCHARGE)

Board: 2 copper layers, 27.9 x 27.9 mm, 16 parts (10 on the bottom side), 9 nets.

## EAGLE design EAGLE Board Designs/Sensor Acquisition Board/Sensor Acquisition Board Rev5.brd

Parts:
CAN_H: TEST_POINT; 5015
CAN_L: TEST_POINT; 5015
J1, J6, J14, J16: CONNECTOR-8_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_08_DUAL
J2, J3, J7, J13, J15: CONNECTOR-4_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_04_DUAL
J4, J5, J9: CONNECTOR-4_μF_S_RA_; MOLEX_MICROFIT_SMD_RIGHTANGLE_04_DUAL
J8: CONNECTOR-2_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_02_DUAL
J10: CONNECTOR-10_MF_T_V_; MOLEX_MICROFIT_PTH_VERTICAL_10_DUAL
J11: CONNECTOR-2_MICROFIT_SMD_RIGHTANGLE_02_SINGLE_BLA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; MOLEX_MICROFIT_SMD_RIGHTANGLE_02_SINGLE
J12: CONNECTOR-6_μF_T_V_BLACK; MOLEX_MICROFIT_PTH_VERTICAL_06_DUAL
JP5V, JP12V, JP24V: JUMPER_0603_; 0603-RES
RH_N: TEST_POINT; 5015
RH_P: TEST_POINT; 5015
RXD: TEST_POINT; 5015
TXD: TEST_POINT; 5015

Connections:
24VIN: J11.1; also elsewhere on the board
+5V: J14.3, J16.3, JP5V.2; also elsewhere on the board
+12V: J2.1, J3.1, J4.1, J5.1, J7.1, J9.1, J10.1, JP12V.2; also elsewhere on the board
+24V: J12.1, J14.4, J15.1, J16.4, JP24V.2; also elsewhere on the board
CAN_N: CAN_L.1, J4.3, J5.3, J9.3, J12.3, J13.3, J15.3; also elsewhere on the board
CAN_P: CAN_H.1, J4.4, J5.4, J9.4, J12.2, J13.2, J15.2; also elsewhere on the board
GND: J1.1, J1.2, J1.3, J1.4, J2.2, J3.2, J4.2, J5.2, J6.1, J6.2, J6.3, J6.4, J7.2, J8.2, J9.2, J10.5, J11.2, J12.6, J13.4, J14.1, J15.4, J16.1; also elsewhere on the board
GPS_PPS: J10.10; also elsewhere on the board
unnamed: J13.1, JP5V.1, JP12V.1, JP24V.1
PI_SHUTDOWN: J8.1; also elsewhere on the board
RESTORE: J10.6; also elsewhere on the board
RHEIGHT_N: J2.3, J3.3, J7.3, RH_N.1; also elsewhere on the board
RHEIGHT_P: J2.4, J3.4, J7.4, RH_P.1; also elsewhere on the board
RL_EXT_N: J14.6; also elsewhere on the board
RL_EXT_P: J14.5; also elsewhere on the board
RR_EXT_N: J16.6; also elsewhere on the board
RR_EXT_P: J16.5; also elsewhere on the board
RXD_232: J10.2, RXD.1; also elsewhere on the board
SHDN_K: J12.4, J14.7
SHDN_L: J14.8, J16.7
SHDN_M: J12.5, J16.2
SYNC_IN: J10.7; also elsewhere on the board
SYNC_OUT: J10.4; also elsewhere on the board
THERM1: J6.8; also elsewhere on the board
THERM2: J6.7; also elsewhere on the board
THERM3: J6.6; also elsewhere on the board
THERM4: J6.5; also elsewhere on the board
THERM5: J1.8; also elsewhere on the board
THERM6: J1.7; also elsewhere on the board
THERM7: J1.6; also elsewhere on the board
THERM8: J1.5; also elsewhere on the board
TXD_232: J10.3, TXD.1; also elsewhere on the board

Notes on the sheet:
Thermistor x8 2 pin each Varied resistance Vertical
Ride height sensor x4 RS485 multidrop Vertical
RL & RR
Aero sensors CAN Vertical
8-channel
64-channel
IMU 10 pin molex 1. RS232 data 2. Power supply Vertical
GLV Power and gnd Vertical
Corner board 1. ADC isoSPI master 2. Power supply 3. Interlock Vertical
CAN 1. Main ECU -> SAB 2. SAB -> TCU/pi 3. Spare Vertical
Distinguish connectors: Color markers Tapes CAN & RS485 Thermistor & corner board
Main ECU Do not connect 24V
Test rail being used Could reduce in next rev
24VIN instead Consider for future rev
Fault prevention: Plug in connector from wrong side SHDN discontinuous GND and supply rails still match
Cecilia Yang
Liwei Sun
Pi shutdown button Vertical
TCU
Spare CAN Various power choices
