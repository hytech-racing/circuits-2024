# Repository hytech-racing/circuits-2024 (continued)

## EAGLE design EAGLE Board Designs/Accumulator Control Unit/Accumulator Control Unit rev6.brd (continued)

Parts:
BSPD_CURRENT: TEST_POINT; MICRO_MINIATURE
C8, C16: CAPACITOR_0603_50V_0.1UF; 0603-CAP
C29: CAPACITOR_0603_25V_0.1UF; 0603-CAP
C30, C33, C61: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C31, C36, C62, C65: CAPACITOR_0603_16V_0.47UF; 0603-CAP
C32, C34, C63, C64: CAPACITOR_0603_10V_1UF; 0603-CAP
C55: CAPACITOR_0603_25V_1UF; 0603-CAP
C56, C57: CAPACITOR_0603_10V_68NF; 0603-CAP
CUR_SHUNT: TEST_POINT; 5015
R22, R23: RESISTOR_0603_10.5K; 0603-RES
R41: RESISTOR_0603_DNP; 0603-RES
R42, R44: RESISTOR_0603_2.74K; 0603-RES
R43: RESISTOR_0603_100K; 0603-RES
R75, R77, R106, R107, R108, R109: RESISTOR_0603_10K; 0603-RES
R76, R78, R122, R125, R126, R128, R131, R132: RESISTOR_0603_12K; 0603-RES
R110: RESISTOR_0603_5.1K; 0603-RES
R111: RESISTOR_0603_4.12K; 0603-RES
R123, R124, R129, R130: RESISTOR_0603_7.5K; 0603-RES
R127, R133: RESISTOR_0603_20K; 0603-RES
U4, U5, U16, U18, U33: OPAMP_1_CHANNEL_OPA991; SC-70-5
U17, U19: OPAMP_2_CHANNEL_OPA_2991; SOT-23-8

Connections:
+3V3: C29.1, C30.1, C33.1, C61.1, R108.2, U16.5 (VDD), U17.8 (VDD), U18.5 (VDD), U19.8 (VDD); also elsewhere on the board
+12V: C55.1, U33.5 (VDD); also elsewhere on the board
+24V: C8.1, C16.1, U4.5 (VDD), U5.5 (VDD); also elsewhere on the board
BSPD_CURRENT: BSPD_CURRENT.1, R23.2, U5.4 (VOUT); also elsewhere on the board
BSPD_CURRENT_REF: R22.2, U4.4 (VOUT); also elsewhere on the board
CURRENT: R43.2, U5.1 (VIN+); also elsewhere on the board
CURRENT_REF: R41.2, U4.1 (VIN+); also elsewhere on the board
CURRENT_SHUNT_OUT: C56.1, CUR_SHUNT.1, R110.1, R111.2; also elsewhere on the board
CURR_N: R106.1; also elsewhere on the board
CURR_P: R107.1; also elsewhere on the board
GND: C8.2, C16.2, C29.2, C30.2, C31.2, C33.2, C36.2, C55.2, C56.2, C61.2, C62.2, C65.2, R41.1, R42.1, R43.1, R44.1, R76.2, R78.2, R110.2, R126.1, R127.1, R132.1, R133.1, U4.2 (GND), U5.2 (GND), U16.2 (GND), U17.4 (GND), U18.2 (GND), U19.4 (GND), U33.2 (GND); also elsewhere on the board
unnamed: R23.1, R44.2, U5.3 (VIN-)
unnamed: C34.2, R124.1, R125.2
unnamed: R22.1, R42.2, U4.3 (VIN-)
unnamed: C36.1, R124.2, U17.5 (VIN+)
unnamed: R77.2, R78.1, U18.1 (VIN+)
unnamed: C32.2, R122.2, R123.1
unnamed: C32.1, R125.1, R126.2, U17.1 (VOUT), U17.2 (VIN-)
unnamed: C31.1, R123.2, U17.3 (VIN+)
unnamed: R75.2, R76.1, U16.1 (VIN+)
unnamed: R107.2, R108.1, U33.1 (VIN+)
unnamed: C57.2, R106.2, R109.1, U33.3 (VIN-)
unnamed: C57.1, R109.2, R111.1, U33.4 (VOUT)
unnamed: C64.2, R130.1, R131.2
unnamed: C65.1, R130.2, U19.5 (VIN+)
unnamed: C63.2, R128.2, R129.1
unnamed: C63.1, R131.1, R132.2, U19.1 (VOUT), U19.2 (VIN-)
unnamed: C62.1, R129.2, U19.3 (VIN+)
PACK+_BUFFER: R128.1, U16.3 (VIN-), U16.4 (VOUT)
PACK+_FILTERED: C64.1, R133.2, U19.6 (VIN-), U19.7 (VOUT); also elsewhere on the board
PACK+_OUT: R75.1; also elsewhere on the board
TS+_OUT: R77.1; also elsewhere on the board
TS+_OUT_BUFFER: R122.1, U18.3 (VIN-), U18.4 (VOUT)
TS+_OUT_FILTERED: C34.1, R127.2, U17.6 (VIN-), U17.7 (VOUT); also elsewhere on the board

Notes on the sheet:
Josh Kirshenbaum
Analog Filtering
5V to 24.16V

Parts:
A3: TEENSY_4.0TH; TEENSY_SHORT
C7, C13, C52, C54: CAPACITOR_0603_10V_10NF; 0603-CAP
C9, C18: CAPACITOR_0603_10V_1UF; 0603-CAP
C10, C11, C19, C20, C22, C37, C53: CAPACITOR_0603_10V_0.1UF; 0603-CAP
C12, C21: CAPACITOR_0603_10V_4.7NF; 0603-CAP
D4, D5, D6, D8: TVS_DO-214AA_28V; DO-214AA
D7: TVS__8V; SOT-23
R7, R9, R11: RESISTOR_0603_36.5K; 0603-RES
R8, R10, R12: RESISTOR_0603_4.64K; 0603-RES
R13, R15: RESISTOR_0603_; 0603-RES
R14: RESISTOR_0603_18.7K; 0603-RES
R16: RESISTOR_0603_5.1K; 0603-RES
R26, R27, R50, R51: RESISTOR_0603_60.4; 0603-RES
R28, R29: RESISTOR_0603_2K; 0603-RES
R30, R103: RESISTOR_0603_1.65K; 0603-RES
R31, R80, R82, R104: RESISTOR_0603_470; 0603-RES
R32, R105: RESISTOR_0603_120; 0603-RES
R45, R102: RESISTOR_0603_1K; 0603-RES
R79, R81, R101: RESISTOR_0603_10K; 0603-RES
T1: TRANSFORMER_HM2112ZNLT_AIRGAP; HM2112ZNLT_AIRGAP
TD1, TD2: CONNECTOR-2_MF_T_V_; MOLEX_MICROFIT_PTH_VERTICAL_02_SINGLE
TD+, TD+2: TEST_POINT; MICRO_MINIATURE
TD-, TD-2: TEST_POINT; MICRO_MINIATURE
TEENSY_OK: LED_0603_RED; 0603-LED
U6, U10: TCAN1051HQV-Q1; SOIC-08(NARROW,0.15")
U7, U32: LTC6820; MSOP-16
U20: LOGICGATE_BUFFER; SC-70-5
U21: ADM8316WBX30; SOT-23-5
WATCHDOG: LED_0603_BLUE; 0603-LED
WATCHDOG_INPUT: TEST_POINT; MICRO_MINIATURE

Connections:
3.3V: A3.3.3V
24V_SCALED_3.3V: A3.D19 (A5), R7.2, R8.1
+3V3: C11.2, C13.2, C20.2, C22.1, C37.2, C52.2, C53.1, R28.2, R29.2, R45.2, R102.2, U6.5 (VIO), U7.1 (VDD), U7.6 (VLOGIC), U7.7 (VDD), U7.8 (VDD), U7.9 (VDD), U7.12 (VDD), U10.5 (VIO), U20.5 (VDD), U21.5 (VDD), U32.1 (VDD), U32.6 (VLOGIC), U32.7 (VDD), U32.8 (VDD), U32.9 (VDD), U32.12 (VDD); also elsewhere on the board
+5V: A3.VIN, C9.2, C10.2, C18.2, C19.2, U6.3 (VDD), U10.3 (VDD); also elsewhere on the board
+24V: D4.2 (C), R7.1; also elsewhere on the board
AMS_OK_3.3V: U20.4 (OUT); also elsewhere on the board
BSPD_CURRENT: D5.2 (C), R9.1; also elsewhere on the board
BSPD_CURRENT_TEENSY: A3.D14 (A0), R9.2, R10.1
CANH: R27.2, U6.7 (CANH); also elsewhere on the board
CANL: R26.2, U6.6 (CANL); also elsewhere on the board
CS_LTC_6820: A3.D10 ((CS)D10), R45.1, U7.5 (!CS)
CURRENT_N_FILT: A3.D20 (A6)
CURRENT_P_FILT: A3.D21 (A7)
CURRENT_SHUNT_OUT: A3.D16 (A2); also elsewhere on the board
EM_CANH: R51.2, U10.7 (CANH); also elsewhere on the board
EM_CANL: R50.2, U10.6 (CANL); also elsewhere on the board
EM_CRX: A3.D23 (A9), U10.4 (RXD)
EM_CTX: A3.D22 (A8), U10.1 (TXD)
GND: A3.AGND/GND (GND), A3.GND, C7.2, C9.1, C10.1, C11.1, C12.1, C13.1, C18.1, C19.1, C20.1, C21.1, C22.2, C37.1, C52.1, C53.2, C54.2, D4.1 (A), D5.1 (A), D6.1 (A), D7.1 (A), D8.1 (A), R8.2, R10.2, R12.2, R13.2, R16.2, R31.2, R79.1, R81.1, R101.1, R104.2, TEENSY_OK.1 (C), U6.2 (GND), U6.8 (S), U7.13 (GND), U7.14 (GND), U10.2 (GND), U10.8 (S), U20.3 (GND), U21.2 (GND), U32.13 (GND), U32.14 (GND), WATCHDOG.1 (C); also elsewhere on the board
IM: T1.10 (TD-), U7.10 (IM)
IMD_OK: D6.2 (C), R11.1; also elsewhere on the board
IMD_OK_TEENSY: A3.D3, R11.2, R12.1
IM_2: T1.7 (TD-), U32.10 (IM)
IP: T1.12 (TD+), U7.11 (IP)
IP_2: T1.9 (TD+), U32.11 (IP)
MHS: D8.2 (C), R15.1; also elsewhere on the board
MHS_TEENSY: A3.D7, R15.2, R16.1
unnamed: A3.D11 ((SDO)D11), R29.1, U7.2 (SDI), U32.2 (SDI)
unnamed: R79.2, U20.2 (IN), U21.1 (!RESET!)
unnamed: C12.2, R26.1, R27.1
unnamed: A3.D0 ((CRX1)D0), U6.4 (RXD)
unnamed: A3.D1 ((CTX1)D1), U6.1 (TXD)
unnamed: C21.2, R50.1, R51.1
unnamed: R30.1, U7.16 (IBIAS)
unnamed: R30.2, R31.1, U7.15 (ICMP)
unnamed: R103.1, U32.16 (IBIAS)
unnamed: C7.1, T1.11 (TCT)
unnamed: A3.D9, R102.1, U32.5 (!CS)
unnamed: R103.2, R104.1, U32.15 (ICMP)
unnamed: A3.D12 ((SDI)D12), R28.1, U7.3 (SDO), U32.3 (SDO)
unnamed: A3.D13 ((CLK)D13), U7.4 (CLK), U32.4 (CLK)
unnamed: R80.1, WATCHDOG.2 (A)
unnamed: R82.1, TEENSY_OK.2 (A)
unnamed: C54.1, T1.8 (TCT)
PACK+_FILTERED: A3.D17 (A3); also elsewhere on the board
PRECHARGE_OK: D7.3 (C), R14.1; also elsewhere on the board
PRECHARGE_OK_TEENSY: A3.D4, R13.1, R14.2
TD1+: R32.2, T1.4 (MX+), TD1.1, TD+.1
TD1-: R32.1, T1.6 (MX-), TD1.2, TD-.1
TD2+: R105.2, T1.1 (MX+), TD2.1, TD+2.1
TD2-: R105.1, T1.3 (MX-), TD2.2, TD-2.1
TEENSY_OK: A3.D6, R82.2, R101.2, U21.3 (!MR!)
TS+_OUT_FILTERED: A3.D18 (A4); also elsewhere on the board
WATCHDOG_INPUT: A3.D5, R80.2, R81.2, U21.4 (WDI), WATCHDOG_INPUT.1

Notes on the sheet:
24V to 3.3V
5V to 3.3V
Watchdog Timer
Voltage Dividers
LTC6820 and Transformer
22V to 3.3V

Board: 4 copper layers, 255.0 x 73.0 mm, 286 parts (4 on the bottom side), 136 nets.

Other parts of the board:
U$1, U$2, U$3, U$4, U$5, U$6: MOUNTING_M4
U$7, U$8: MOUNTING_M3
U$9: TS
U$10, U$11, U$13, U$14, U$15, U$101: HV_MEDIUM
U$12: LOGO_HYTECH_SQUARE_EXTRA_LARGE
U$16: LOGO_HYTECH_LARGE
U$17: LOGO_GT_MEDIUM
U$19: DANGER_HIGH_VOLTAGE

File EAGLE Board Designs/Accumulator Control Unit/Order Files/Accumulator Control Unit rev4_top_bom.csv:

Comment,Designator,Footprint,LCSC Part #
ADG1423,U27,MSOP-10,
ADM8316WBX30,U21,SOT-23-5,
CAPACITOR_0603_10V_0.1UF,C10 C11 C14 C15 C19 C20 C22 C23 C24 C25 C30 C31 C33 C34 C35 C37 C38 C39 C40 C41 C42 C45 C46 C48 C49 C50,0603-CAP,
CAPACITOR_0603_10V_1UF,C6 C9 C18,0603-CAP,
CAPACITOR_0603_10V_4.7NF,C12 C21,0603-CAP,
CAPACITOR_0603_10V_4.7UF,C5 C28,0603-CAP,
CAPACITOR_0603_10V_10NF,C7 C13 C17,0603-CAP,
CAPACITOR_0603_10V_680PF,C32 C36 C47 C51,0603-CAP,
CAPACITOR_0603_25V_0.1UF,C26 C29 C44,0603-CAP,
CAPACITOR_0603_25V_1UF,C27 C43,0603-CAP,
CAPACITOR_0603_25V_10UF,C4,0603-CAP,
CAPACITOR_0603_50V_0.1UF,C8 C16,0603-CAP,
CAPACITOR_0805_50V_10UF,C1 C2 C3,0805-CAP,
FUSE_0603_.75A,F1 F2,0603-FUSE,
LED_0603_BLUE,5V WATCHDOG,0603-LED,
LED_0603_GREEN,3.3V AMS_OK TSAL_GREEN,0603-LED,
LED_0603_ORANGE,24V IMD_OK,0603-LED,
LED_0603_RED,12V PRECHARGE_OK TEENSY_OK TSAL_RED,0603-LED,
LED_0603_YELLOW,OKHS,0603-LED,
LM555,U15,SOIC-08(NARROW 0.15"),
LOGICGATE_AND_DCK3,U23 U24 U25,SC-70-5,
LOGICGATE_BUFFER,U20,SC-70-5,
LTC6820,U7,MSOP-16,
MAX7404,U17,SOIC-08(NARROW 0.15"),
MAX7404,U19,SOIC-08(NARROW 0.15"),
MAX7404,U29,SOIC-08(NARROW 0.15"),
MAX7404,U31,SOIC-08(NARROW 0.15"),
OPAMP_1_CHANNEL_OPA991,U4 U5 U8 U9 U11 U12 U13 U16 U18 U22 U26 U28 U30,SC-70-5,
RELAY_SOLIDSTATE_NO_CPC1020NTR,K1,SOP-04,
RELAY_SOLIDSTATE_NO_DIP-4,U2 U3 U14,DIP-4,
RESISTOR_0603_,R13 R15,0603-RES,
RESISTOR_0603_1K,R24 R30 R31 R65 R73 R83 R96,0603-RES,
RESISTOR_0603_1M,R92,0603-RES,
RESISTOR_0603_2.2K,R17 R19,0603-RES,
RESISTOR_0603_2.74K,R42 R44,0603-RES,
RESISTOR_0603_2K,R18 R25 R28 R29 R48 R72 R74 R95,0603-RES,
RESISTOR_0603_3.3K,R49,0603-RES,
RESISTOR_0603_4.64K,R8 R10 R12,0603-RES,
RESISTOR_0603_5.1K,R4 R16 R21,0603-RES,
RESISTOR_0603_5.9K,R54,0603-RES,
RESISTOR_0603_8.66K,R93,0603-RES,
RESISTOR_0603_10,R1 R6 R70 R71,0603-RES,
RESISTOR_0603_10.5K,R22 R23 R33 R34 R37 R38,0603-RES,
RESISTOR_0603_10K,R2 R5 R45 R46 R47 R55 R56 R57 R61 R62 R66 R67 R69 R75 R77 R79 R81 R86 R87 R88 R91 R94 R97 R99 R101,0603-RES,
RESISTOR_0603_11.5K,R53,0603-RES,
RESISTOR_0603_12K,R76 R78 R98 R100,0603-RES,
RESISTOR_0603_13K,R35 R36 R39 R40,0603-RES,
RESISTOR_0603_14K,R63 R84,0603-RES,
RESISTOR_0603_18.7K,R14,0603-RES,
RESISTOR_0603_20K,R3 R20,0603-RES,
RESISTOR_0603_36.5K,R7 R9 R11 R58,0603-RES,
RESISTOR_0603_43K,R68,0603-RES,
RESISTOR_0603_60.4,R26 R27 R50 R51,0603-RES,
RESISTOR_0603_73.2K,R90,0603-RES,
RESISTOR_0603_100K,R41 R43,0603-RES,
RESISTOR_0603_120,R32,0603-RES,
RESISTOR_0603_330K,R59,0603-RES,
RESISTOR_0603_470,R80 R82 R89,0603-RES,
RESISTOR_0603_DNP,R52 R60 R64 R85,0603-RES,
TCAN1051HQV-Q1,U6,SOIC-08(NARROW 0.15"),
TCAN1051HQV-Q1,U10,SOIC-08(NARROW 0.15"),
TEST_POINT,BSPD_CURRENT CURRENT_REF CURRENT_SENSE PACK+_OUT_TEST PRECHARGE_OK_TEST TD+ TD-,MICRO_MINIATURE,
TEST_POINT,TP_3.3V TP_5V TP_12V TP_24V,5015,
TEST_POINT,TP_AMS_OK,MICRO_MINIATURE,
TEST_POINT,TP_GND,5015,
TEST_POINT,TP_IMD_OK TP_TSAL_GREEN TP_TSAL_RED TS+_OUT_TEST WATCHDOG_INPUT,MICRO_MINIATURE,
TRANSFORMER_HM2112ZNLT_AIRGAP,T1,HM2112ZNLT_AIRGAP,
TRANSISTOR_N_MOS__PMV15ENEA,Q1 Q2 Q3 Q4,SOT-23,
TVS_8V,D1 D3 D7,SOT-23,
TVS_15V,D9 D10,SOT-23,
TVS_28VDO-214AA,D4 D5 D6 D8,DO-214AA,
TVS_30VDO-214AA,D2,DO-214AA,
VOLTAGE_REGULATOR_SOT-223_3.3V,U1,SOT-223,

## Commit log (part)

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2023-10-26 Revert "Update Accumulator Control Unit rev6.brd"
    This reverts commit 9c4b5f8b499e9f513b432cb31a22ac7dede785b9.
2023-10-26 updated board dimmentions
2023-10-26 Board Test
2023-10-26 Board changes
2023-10-26 replaced diode
2023-10-26 tsb-rev8-layout-udpate
    updated m4 mounting holes
2023-10-27 Update dashboard-rev-7
2023-10-27 Swap for 14V TVS
2023-10-28 updated the IMD holes to work
2023-10-29 tsb-rev8-layout-update
    finalizations
2023-10-29 tsb-rev8
    ordering files
2023-10-29 adjust schematic
2023-10-29 Adjusted schematic
    Added thermistors
2023-10-29 new board just started rev
2023-10-29 Added engineer name
2023-10-30 Fixed Shayan's bad work
2023-10-30 grouping done
2023-10-30 moved analog port to be easier for routing
2023-10-30 Added some routes
2023-10-30 Completed routing
2023-10-30 Final update
2023-10-30 DRC and cam file
2023-10-30 checkpoint
2023-10-30 changed miso and mosi
2023-10-30 6 layer moment
2023-10-30 set layout
2023-10-30 Connected RX correctly
2023-10-30 num num
2023-10-30 DRC fix
2023-10-31 added order files and did schem/board review
2023-10-31 tsb-rev8-update
    updated connector names on schematic and layout
2023-10-31 everything except power
2023-10-31 going crazy
2023-10-31 Replaced iso_TS and iso_Pack processing resistors
2023-10-31 orderfiles
2023-10-31 sexy wiring
2023-10-31 a lil more (just power left i think
2023-10-31 order files
2023-10-31 shifted stuff over
2023-11-01 tsb-rev8-ordering-updates
2023-11-01 Routing started
2023-11-01 changed pins to have a can in and out
2023-11-01 finito
2023-11-01 Continue routing
2023-11-01 approved all correct overlaps
2023-11-02 Updated order file
2023-11-03 changed some stuff to make it look better
2023-11-03 some routes
2023-11-03 mikhail prelim review
    changes that need to be made have been recorded
2023-11-03 num num num
2023-11-04 adjusted layout
2023-11-05 schematics for esf
2023-11-05 isospi needs to change
2023-11-05 Added resistors to CC1 and CC2 for actual functionality
2023-11-05 done day
2023-11-05 dimension trim
2023-11-05 Cleaned up/reviewed schem
2023-11-05 Added green button shutdown pi
2023-11-06 some routes before Eagle crashes
2023-11-06 differential routing length matching
    99.8% RR
2023-11-06 some power routes
2023-11-06 Added Thermistor Expansion Module
    Added board to read thermistors.
2023-11-06 save
2023-11-06 Added ordering files
    Added files for ordering parts for board.
2023-11-06 Began PCB layout, schematic changes to reflect layout
2023-11-07 Made updates to schematic, continuing layout, began routing
2023-11-07 added more ESF diagrams
2023-11-07 fixing stuff from brd review
2023-11-07 major routing fixes
2023-11-07 quick fix
2023-11-07 Completed more routing, small schematic updates
2023-11-08 adjusted dimension
2023-11-08 small changes
2023-11-08 passed drc
2023-11-08 More Routing
2023-11-10 Almost Finished routing, added new parts and added second display connectors
2023-11-10 what am i doing
2023-11-10 changed capacitors and can bus transceiver
    changed capacitors and can bus transceiver
2023-11-10 started work
2023-11-11 getting this done edited the shutdown
2023-11-11 awaiting sab connections
2023-11-11 mics changes
2023-11-11 shdn updates
2023-11-12 Update sch brd
    add dcdc modules, some placement
2023-11-12 finalized schem
2023-11-12 add pcb
    add pcb
2023-11-12 changes
    changed USBC footprint
2023-11-12 need to change filters + add steering
2023-11-12 schem review
2023-11-13 fixing broken stuff
2023-11-14 added reviewer names
2023-11-14 updated fuse value
2023-11-14 routing
    routing
2023-11-14 updated with esf and prelim filter changes
    this is gonna be hell to reroute
2023-11-15 Rough Placement of neopixels
2023-11-15 layout
    layout
2023-11-16 changes after review
2023-11-17 initiial layout
2023-11-17 layout
    finalize layout
2023-11-17 Finished routing dash rev 7
2023-11-18 Fixes to power planes and routing
2023-11-19 Added silk, more gnd vias
2023-11-19 More vias
2023-11-19 Cosmetic fixes
2023-11-19 Cleaning
2023-11-20 oderfiles
2023-11-20 Cleanup, better GND return path for SPI2
2023-11-20 bom highlighting
2023-11-21 repositioned D2 and vias on designators
    layout changes: repositioned D2 and vias on designators
2023-11-22 routes
2023-11-22 Finishing touches, silkscreen modification, changed dial connector, added decoupling cap
2023-11-22 dale papa
2023-11-22 updated filters and bspd circuitry
2023-11-23 made changes from review
    layout and schematic change from review
2023-11-24 quixk
2023-11-25 Finishing up
    Swap connectors
    Round corners
    Edge plating
2023-11-26 Added jumper and shottky for bypassing VBUS capacitance
2023-11-26 new layout with expanded pedal connector
2023-11-26 layout
2023-11-26 Changed LEDs and Resistor values
2023-11-27 woohoo filter added!!!!
2023-11-27 no drc errors
2023-11-28 added new filters
2023-11-28 himothy
2023-11-28 edge polygon
2023-11-28 some route fix
2023-11-29 Update Main Ecu rev15
2023-11-29 add descriptions and move via
2023-11-29 Modifications/cleanup
2023-11-29 review notes
2023-11-30 move steering connector
2023-12-01 change connectors
2023-12-01 finish routing
2023-12-01 add vias to stop plane cutup
2023-12-01 quick lil changes
2023-12-02 fixing dif pairs spaciong
2023-12-02 fixed diff pair routing
2023-12-02 changed filters
2023-12-02 SAVE of changes before I rip up everything
2023-12-02 got rid of all routes
2023-12-02 swaped some of the pins around for easier routing
2023-12-02 no more DRC errors
2023-12-02 more power vias
2023-12-02 upload to git
2023-12-02 updated fill
2023-12-03 made bspd look nicer
2023-12-03 ok now updated
2023-12-03 in grey
2023-12-03 asthetics
2023-12-03 astehtics
2023-12-03 reroute
2023-12-03 fixed merge conflict
2023-12-04 thermistor cap notes
2023-12-04 acu_rev6_schematic_update
    moved precharge control circuit difference amplifiers' pull down resistors to between the differential inputs
2023-12-04 acu-rev6-schematic-update
    some changes to precharge control circuit
2023-12-04 fixed all drc errrors again
2023-12-04 Added RPP with mosfet need to double check
2023-12-04 some more changes
2023-12-04 Added HV silkscreen
2023-12-04 added Silkscreen stuff
2023-12-04 acu-rev6-update
    some quick fixes
2023-12-04 acu-rev6-handoff
2023-12-05 temp changes
2023-12-05 routing differential pairs
2023-12-05 quick change
2023-12-05 fixed conflicts
2023-12-05 final change
2023-12-05 near final dash design with shottky and usb esd
2023-12-05 swap max's for 1uF cap
2023-12-06 brendan changes
2023-12-06 finish routing + pass drc
2023-12-06 Add RPP Diode and Resistor
2023-12-08 Finished, submitted for ordering
2023-12-09 stitching vias
2023-12-09 asthetic
2023-12-10 exported step file
2023-12-10 connector board fixes
2023-12-10 quick updates
2023-12-13 Post review modifications
    changed schematic and layout after 1st review
2023-12-13 layout
    flipped washers to the top
2023-12-14 ready for review
2023-12-15 okok
2023-12-15 ready to order
2023-12-15 layout change
    add stitching vias
2023-12-16 some schematic changes and routes
2023-12-17 2nd review changes
    added can transceiver
2023-12-17 moving digital circuitry upward
2023-12-17 2nd review changes
    2nd review changes
2023-12-18 some final routes
2023-12-18 adjusting stitching vias
2023-12-18 clean up bom
    clean up bom
2023-12-18 review changes
2023-12-19 assembly
    assembly layer
2023-12-19 shifted cap pos
2023-12-19 design locked
2023-12-19 swapped rs232 and rs485 caps for higher voltage ratings
2023-12-19 updates on things that are wrong
2023-12-20 mega stitch
2023-12-20 output jobs files
    generated gerber
2023-12-20 order files added
2023-12-20 regenerate output files
    regenerate output files
2023-12-20 gerber
    gerber and drills
2023-12-20 done
2023-12-20 final adjustments, ordering finalized
2023-12-20 changed air+ to be accurate
    still need to change precharge stuff
2023-12-21 updated schematic block
2023-12-21 adding reviewers
2023-12-21 grinded comments
2023-12-21 comment finalized
2023-12-21 connected some gnd vias and adjusted shdn pos
2023-12-21 rotate dash
2023-12-21 CAM updated
2023-12-25 added margin measurement
2023-12-25 rs485 firmware pin notes
2023-12-25 Revert "rs485 firmware pin notes"
    This reverts commit 5b99e37346135fe8be61798346ccc42894d34ddc.
2023-12-28 straightened some unnecessary traces
2023-12-28 added new filters and blah
2023-12-28 rev16 schematic done
2023-12-28 moving around diff pairs
2023-12-29 diff pairs routed
2023-12-29 finished diff pairs
2023-12-29 swapped 20 pin molex and adjusted connector pos
2023-12-29 align ribbon conn pos with ECU
2023-12-29 work
2023-12-29 very nice
2023-12-29 added eric
2023-12-29 cleared drc
2023-12-29 enlarged copper pour underneath fuse
2023-12-30 nice
2023-12-30 more nice
2023-12-30 fixing filter config
2023-12-30 routed adcs somewhat
2023-12-30 somewhat done?
2023-12-30 fix firewall connector
2024-01-01 most of placement and routing done
2024-01-01 almost almost done, Happy New Year
2024-01-01 finished
2024-01-01 ok finito
2024-01-01 okok finito
2024-01-04 ACU before getting rid of extra filters
2024-01-04 Changes with Filters removed
2024-01-04 removed 3.3V from teensy
2024-01-04 rerouted diff pair
2024-01-04 added ordering externals
2024-01-06 fixed
2024-01-06 went back to the og strat because too lazy
2024-01-06 finalized changes
2024-01-06 CAN tp space
2024-01-06 num num adjusted resisor values to be cheaper
2024-01-06 Changed via sizes to be cheaper
2024-01-07 ordering files
2024-01-14 added current shunt MPN
2024-01-23 Added TSAL_rev6 from 2022
2024-03-22 rev9-reroute-first-attempt
    modified based on femke's design
2024-03-22 small update
2024-03-22 updated precharge relay
2024-03-25 sch changes from testing
2024-03-26 More changes for ESF
2024-03-29 some more routing
2024-03-29 removed ail connector
2024-04-01 added tvs on TS
2024-04-02 silkscreens
2024-04-06 finalizing first draft
2024-04-06 changed nrnd diode
2024-05-09 changed 12V LED resistor
2024-05-09 UPdate parts and placement notes on sheet 3
2024-05-27 made it better
2024-06-05 updated schem
2024-06-06 changed precharge resistors
2024-06-06 tsb_rev9 layout silkscreen changes
2024-06-23 Adding altium project for STM32 display test board
    Added MCU, CAN, and basic USB schems
    Added 3v3 buck and neopixel circuitry
    Finished work on power delivery, added display headers, ST Link, and 7-segment display
    Finished MCU connects and added ESD and Fuse Circuitry. Began PCB Layout
    Swapped out 7-seg and Driver
    Progress in routing board, removed redundant circuitry, modified layouts
2024-07-05 Creating raspberry pi telemetry board
    delete
    gitignore
    what am i doing
    changed capacitors and can bus transceiver
    changed capacitors and can bus transceiver
    mics changes
2024-07-07 Revert "Merge branch 'main' into tsb-rev7"
    This reverts commit 196606aab197effcf88f570fe500960d66af2677, reversing
    changes made to 9a120937e6b611b77665cb0a3130705a6a517e84.
2024-08-27 Added initial BMS rev 20 schematic
    Want to update LTC 6811-1 part to make some of the pin labelings cleaner (especially on the bottom IC).
2024-08-27 Updated Frames
    Updated Frame names for changed sheets.
2024-08-28 Test Point and Termination Update
    Got rid of test points -- will use exposed pads on DNP resistors instead -- DNP resistors can be used for termination on last chip as well.
2024-08-28 Added Coupling Capacitors
    Added Coupling Capacitors for isolation and to filter out DC noise in series for on-board chip-to-chip connection.
2024-09-15 Initial rev20 Board Routing
    Initial routing for BMS rev20 board.
2024-09-22 Updates to Board
    Added updates to board design.
2024-09-29 Updated silkscreen
    Updated component name positioning on silkscreen.
2024-09-29 Silkscreen change
    Updated one silkscreen placement.
2024-09-29 Added New Fuse Component
    Changed fuses to cheaper, smaller package fuse components -- handles 3A, 125VDC.
2024-10-28 New Temperature Measurement
    Added new board temperature measurement IC.
2024-10-28 Added Ordering Files
    Added Ordering Files
